/**
 * @file main.c
 * @brief HKDF Test - RFC 5869 Test Vectors
 */

#include <stdbool.h>
#include <stdint.h>
#include <string.h>
#include <stdio.h>
#include <ti/screen.h>
#include <ti/getkey.h>
#include <time.h>

/* TLS includes */
#include <lwip/cryptography/hkdf.h>
#include <lwip/cryptography/hash.h>
#include <lwip/cryptography/hmac.h>
#include <lwip.h>

static volatile uint8_t timing_sink = 0;

struct timing_group {
    uint16_t len;
    uint16_t samples;
    uint32_t mean;
    uint32_t stddev;
    uint32_t pct_x100;
};

static uint32_t isqrt_u64(uint64_t x)
{
    uint64_t op = x;
    uint64_t res = 0;
    uint64_t one = (uint64_t)1 << 62;
    while (one > op)
        one >>= 2;
    while (one != 0)
    {
        if (op >= res + one)
        {
            op -= res + one;
            res = (res >> 1) + one;
        }
        else
        {
            res >>= 1;
        }
        one >>= 2;
    }
    return (uint32_t)res;
}

static void compute_stats(const uint32_t *samples, uint16_t count, struct timing_group *out)
{
    uint64_t sum = 0;
    for (uint16_t i = 0; i < count; i++)
        sum += samples[i];
    uint32_t mean = (count != 0) ? (uint32_t)(sum / count) : 0;
    uint64_t var_sum = 0;
    for (uint16_t i = 0; i < count; i++)
    {
        int64_t diff = (int64_t)samples[i] - (int64_t)mean;
        var_sum += (uint64_t)(diff * diff);
    }
    uint32_t var = (count != 0) ? (uint32_t)(var_sum / count) : 0;
    uint32_t stddev = isqrt_u64(var);
    uint32_t pct_x100 = (mean != 0) ? (uint32_t)(((uint64_t)stddev * 10000u) / mean) : 0;
    out->mean = mean;
    out->stddev = stddev;
    out->pct_x100 = pct_x100;
}

static uint32_t time_hkdf(const uint8_t *ikm, size_t ikm_len)
{
    uint8_t prk[32];
    uint8_t okm[32];
    uint8_t salt[32];
    uint8_t info[16];
    for (uint8_t i = 0; i < sizeof(salt); i++)
        salt[i] = (uint8_t)(0xa0 + i);
    for (uint8_t i = 0; i < sizeof(info); i++)
        info[i] = (uint8_t)(0x10 + i);
    clock_t start = clock();
    bool ok = tls_hkdf_extract(TLS_HASH_SHA256, salt, sizeof(salt), ikm, ikm_len, prk);
    if (ok)
        ok = tls_hkdf_expand(TLS_HASH_SHA256, prk, sizeof(prk), info, sizeof(info), okm, sizeof(okm));
    timing_sink ^= okm[0];
    if (!ok)
        timing_sink ^= 0xFF;
    return (uint32_t)(clock() - start);
}

/* Test functions remain the same - keeping existing implementations */
/**
 * RFC 5869 Test Case 1
 * Hash = SHA-256
 */
static bool test_hkdf_rfc5869_case1(void) {
    /* Test vector from RFC 5869 A.1 */
    const uint8_t ikm[] = {
        0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b,
        0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b,
        0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b
    };
    const uint8_t salt[] = {
        0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
        0x08, 0x09, 0x0a, 0x0b, 0x0c
    };
    const uint8_t info[] = {
        0xf0, 0xf1, 0xf2, 0xf3, 0xf4, 0xf5, 0xf6, 0xf7,
        0xf8, 0xf9
    };

    const uint8_t expected_prk[] = {
        0x07, 0x77, 0x09, 0x36, 0x2c, 0x2e, 0x32, 0xdf,
        0x0d, 0xdc, 0x3f, 0x0d, 0xc4, 0x7b, 0xba, 0x63,
        0x90, 0xb6, 0xc7, 0x3b, 0xb5, 0x0f, 0x9c, 0x31,
        0x22, 0xec, 0x84, 0x4a, 0xd7, 0xc2, 0xb3, 0xe5
    };

    const uint8_t expected_okm[] = {
        0x3c, 0xb2, 0x5f, 0x25, 0xfa, 0xac, 0xd5, 0x7a,
        0x90, 0x43, 0x4f, 0x64, 0xd0, 0x36, 0x2f, 0x2a,
        0x2d, 0x2d, 0x0a, 0x90, 0xcf, 0x1a, 0x5a, 0x4c,
        0x5d, 0xb0, 0x2d, 0x56, 0xec, 0xc4, 0xc5, 0xbf,
        0x34, 0x00, 0x72, 0x08, 0xd5, 0xb8, 0x87, 0x18,
        0x58, 0x65
    };

    uint8_t prk[32];
    uint8_t okm[42];

    /* Test HKDF-Extract */
    if (!tls_hkdf_extract(TLS_HASH_SHA256, salt, sizeof(salt),
                          ikm, sizeof(ikm), prk)) {
        return false;
    }

    if (memcmp(prk, expected_prk, sizeof(expected_prk)) != 0) {
        return false;
    }

    /* Test HKDF-Expand */
    if (!tls_hkdf_expand(TLS_HASH_SHA256, prk, sizeof(prk),
                         info, sizeof(info), okm, sizeof(okm))) {
        return false;
    }

    if (memcmp(okm, expected_okm, sizeof(expected_okm)) != 0) {
        return false;
    }

    return true;
}

/**
 * RFC 5869 Test Case 2
 * Hash = SHA-256
 * Longer inputs/outputs
 */
static bool test_hkdf_rfc5869_case2(void) {
    /* Test vector from RFC 5869 A.2 */
    const uint8_t ikm[] = {
        0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
        0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
        0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
        0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f,
        0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27,
        0x28, 0x29, 0x2a, 0x2b, 0x2c, 0x2d, 0x2e, 0x2f,
        0x30, 0x31, 0x32, 0x33, 0x34, 0x35, 0x36, 0x37,
        0x38, 0x39, 0x3a, 0x3b, 0x3c, 0x3d, 0x3e, 0x3f,
        0x40, 0x41, 0x42, 0x43, 0x44, 0x45, 0x46, 0x47,
        0x48, 0x49, 0x4a, 0x4b, 0x4c, 0x4d, 0x4e, 0x4f
    };

    const uint8_t salt[] = {
        0x60, 0x61, 0x62, 0x63, 0x64, 0x65, 0x66, 0x67,
        0x68, 0x69, 0x6a, 0x6b, 0x6c, 0x6d, 0x6e, 0x6f,
        0x70, 0x71, 0x72, 0x73, 0x74, 0x75, 0x76, 0x77,
        0x78, 0x79, 0x7a, 0x7b, 0x7c, 0x7d, 0x7e, 0x7f,
        0x80, 0x81, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87,
        0x88, 0x89, 0x8a, 0x8b, 0x8c, 0x8d, 0x8e, 0x8f,
        0x90, 0x91, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97,
        0x98, 0x99, 0x9a, 0x9b, 0x9c, 0x9d, 0x9e, 0x9f,
        0xa0, 0xa1, 0xa2, 0xa3, 0xa4, 0xa5, 0xa6, 0xa7,
        0xa8, 0xa9, 0xaa, 0xab, 0xac, 0xad, 0xae, 0xaf
    };

    const uint8_t info[] = {
        0xb0, 0xb1, 0xb2, 0xb3, 0xb4, 0xb5, 0xb6, 0xb7,
        0xb8, 0xb9, 0xba, 0xbb, 0xbc, 0xbd, 0xbe, 0xbf,
        0xc0, 0xc1, 0xc2, 0xc3, 0xc4, 0xc5, 0xc6, 0xc7,
        0xc8, 0xc9, 0xca, 0xcb, 0xcc, 0xcd, 0xce, 0xcf,
        0xd0, 0xd1, 0xd2, 0xd3, 0xd4, 0xd5, 0xd6, 0xd7,
        0xd8, 0xd9, 0xda, 0xdb, 0xdc, 0xdd, 0xde, 0xdf,
        0xe0, 0xe1, 0xe2, 0xe3, 0xe4, 0xe5, 0xe6, 0xe7,
        0xe8, 0xe9, 0xea, 0xeb, 0xec, 0xed, 0xee, 0xef,
        0xf0, 0xf1, 0xf2, 0xf3, 0xf4, 0xf5, 0xf6, 0xf7,
        0xf8, 0xf9, 0xfa, 0xfb, 0xfc, 0xfd, 0xfe, 0xff
    };

    const uint8_t expected_prk[] = {
        0x06, 0xa6, 0xb8, 0x8c, 0x58, 0x53, 0x36, 0x1a,
        0x06, 0x10, 0x4c, 0x9c, 0xeb, 0x35, 0xb4, 0x5c,
        0xef, 0x76, 0x00, 0x14, 0x90, 0x46, 0x71, 0x01,
        0x4a, 0x19, 0x3f, 0x40, 0xc1, 0x5f, 0xc2, 0x44
    };

    const uint8_t expected_okm[] = {
        0xb1, 0x1e, 0x39, 0x8d, 0xc8, 0x03, 0x27, 0xa1,
        0xc8, 0xe7, 0xf7, 0x8c, 0x59, 0x6a, 0x49, 0x34,
        0x4f, 0x01, 0x2e, 0xda, 0x2d, 0x4e, 0xfa, 0xd8,
        0xa0, 0x50, 0xcc, 0x4c, 0x19, 0xaf, 0xa9, 0x7c,
        0x59, 0x04, 0x5a, 0x99, 0xca, 0xc7, 0x82, 0x72,
        0x71, 0xcb, 0x41, 0xc6, 0x5e, 0x59, 0x0e, 0x09,
        0xda, 0x32, 0x75, 0x60, 0x0c, 0x2f, 0x09, 0xb8,
        0x36, 0x77, 0x93, 0xa9, 0xac, 0xa3, 0xdb, 0x71,
        0xcc, 0x30, 0xc5, 0x81, 0x79, 0xec, 0x3e, 0x87,
        0xc1, 0x4c, 0x01, 0xd5, 0xc1, 0xf3, 0x43, 0x4f,
        0x1d, 0x87
    };

    uint8_t prk[32];
    uint8_t okm[82];

    /* Test HKDF-Extract */
    if (!tls_hkdf_extract(TLS_HASH_SHA256, salt, sizeof(salt),
                          ikm, sizeof(ikm), prk)) {
        return false;
    }

    if (memcmp(prk, expected_prk, sizeof(expected_prk)) != 0) {
        return false;
    }

    /* Test HKDF-Expand */
    if (!tls_hkdf_expand(TLS_HASH_SHA256, prk, sizeof(prk),
                         info, sizeof(info), okm, sizeof(okm))) {
        return false;
    }

    if (memcmp(okm, expected_okm, sizeof(expected_okm)) != 0) {
        return false;
    }

    return true;
}

/**
 * RFC 5869 Test Case 3
 * Hash = SHA-256
 * No salt, no info
 */
static bool test_hkdf_rfc5869_case3(void) {
    /* Test vector from RFC 5869 A.3 */
    const uint8_t ikm[] = {
        0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b,
        0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b,
        0x0b, 0x0b, 0x0b, 0x0b, 0x0b, 0x0b
    };

    const uint8_t expected_prk[] = {
        0x19, 0xef, 0x24, 0xa3, 0x2c, 0x71, 0x7b, 0x16,
        0x7f, 0x33, 0xa9, 0x1d, 0x6f, 0x64, 0x8b, 0xdf,
        0x96, 0x59, 0x67, 0x76, 0xaf, 0xdb, 0x63, 0x77,
        0xac, 0x43, 0x4c, 0x1c, 0x29, 0x3c, 0xcb, 0x04
    };

    const uint8_t expected_okm[] = {
        0x8d, 0xa4, 0xe7, 0x75, 0xa5, 0x63, 0xc1, 0x8f,
        0x71, 0x5f, 0x80, 0x2a, 0x06, 0x3c, 0x5a, 0x31,
        0xb8, 0xa1, 0x1f, 0x5c, 0x5e, 0xe1, 0x87, 0x9e,
        0xc3, 0x45, 0x4e, 0x5f, 0x3c, 0x73, 0x8d, 0x2d,
        0x9d, 0x20, 0x13, 0x95, 0xfa, 0xa4, 0xb6, 0x1a,
        0x96, 0xc8
    };

    uint8_t prk[32];
    uint8_t okm[42];

    /* Test HKDF-Extract with no salt */
    if (!tls_hkdf_extract(TLS_HASH_SHA256, NULL, 0,
                          ikm, sizeof(ikm), prk)) {
        return false;
    }

    if (memcmp(prk, expected_prk, sizeof(expected_prk)) != 0) {
        return false;
    }

    /* Test HKDF-Expand with no info */
    if (!tls_hkdf_expand(TLS_HASH_SHA256, prk, sizeof(prk),
                         NULL, 0, okm, sizeof(okm))) {
        return false;
    }

    if (memcmp(okm, expected_okm, sizeof(expected_okm)) != 0) {
        return false;
    }

    return true;
}

/**
 * Test HKDF-Expand-Label for TLS 1.3 (RFC 8446 section 7.1) against the
 * published RFC 8448 section 3 "Simple 1-RTT Handshake" vectors.
 *
 * Derive-Secret(handshake_secret, "c hs traffic", hello_hash) must equal
 * the documented client_handshake_traffic_secret. This exercises the real
 * HkdfLabel construction end to end: the "tls13 " prefix, the label, and
 * the context (here, a transcript hash rather than empty), not just
 * HKDF-Expand in isolation (already covered by the RFC 5869 cases above).
 */
static bool test_hkdf_expand_label(void) {
    /* RFC 8448 3, handshake secret (output of
     * HKDF-Extract with salt=derived-handshake-secret, ikm=(EC)DHE) */
    const uint8_t handshake_secret[] = {
        0x1d, 0xc8, 0x26, 0xe9, 0x36, 0x06, 0xaa, 0x6f,
        0xdc, 0x0a, 0xad, 0xc1, 0x2f, 0x74, 0x1b, 0x01,
        0x04, 0x6a, 0xa6, 0xb9, 0x9f, 0x69, 0x1e, 0xd2,
        0x21, 0xa9, 0xf0, 0xca, 0x04, 0x3f, 0xbe, 0xac
    };

    /* RFC 8448 3, hash of ClientHello..ServerHello (the "hello_hash") */
    const uint8_t hello_hash[] = {
        0x86, 0x0c, 0x06, 0xed, 0xc0, 0x78, 0x58, 0xee,
        0x8e, 0x78, 0xf0, 0xe7, 0x42, 0x8c, 0x58, 0xed,
        0xd6, 0xb4, 0x3f, 0x2c, 0xa3, 0xe6, 0xe9, 0x5f,
        0x02, 0xed, 0x06, 0x3c, 0xf0, 0xe1, 0xca, 0xd8
    };

    /* RFC 8448 3, expected client_handshake_traffic_secret =
     * Derive-Secret(handshake_secret, "c hs traffic", hello_hash) */
    const uint8_t expected_chts[] = {
        0xb3, 0xed, 0xdb, 0x12, 0x6e, 0x06, 0x7f, 0x35,
        0xa7, 0x80, 0xb3, 0xab, 0xf4, 0x5e, 0x2d, 0x8f,
        0x3b, 0x1a, 0x95, 0x07, 0x38, 0xf5, 0x2e, 0x96,
        0x00, 0x74, 0x6a, 0x0e, 0x27, 0xa5, 0x5a, 0x21
    };

    uint8_t chts[32];

    /* Derive-Secret(Secret, Label, Messages) =
     *     HKDF-Expand-Label(Secret, Label, Transcript-Hash(Messages), Hash.length)
     * -- here the transcript hash is supplied directly rather than fed
     * through an incremental hash context, since this test only exercises
     * the label/context construction, not transcript hashing itself. */
    if (!tls_hkdf_expand_label(TLS_HASH_SHA256, handshake_secret, sizeof(handshake_secret),
                               "c hs traffic", 12, hello_hash, sizeof(hello_hash),
                               chts, sizeof(chts))) {
        return false;
    }

    return memcmp(chts, expected_chts, sizeof(expected_chts)) == 0;
}

/* Full TLS 1.3 SHA-384 key schedule for TLS_AES_256_GCM_SHA384. The
 * transcript is a fixed byte string; every intermediate is compared with a
 * reference computed independently in Python (hashlib/hmac). This exercises
 * the same generic primitives the handshake key schedule uses: transcript
 * hashing, HKDF-Extract, Derive-Secret/Expand-Label, AES-256 key/IV expansion
 * and the Finished HMAC with a 48-byte verify_data. */
static bool test_tls13_sha384_key_schedule(void) {
    static const uint8_t ecdhe[32] = {
        0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
        0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
        0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
        0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f
    };
    static const uint8_t transcript[] = "fake ClientHello"
                                        "fake ServerHello";
    static const uint8_t expected_early[48] = {
        0x7e, 0xe8, 0x20, 0x6f, 0x55, 0x70, 0x02, 0x3e,
        0x6d, 0xc7, 0x51, 0x9e, 0xb1, 0x07, 0x3b, 0xc4,
        0xe7, 0x91, 0xad, 0x37, 0xb5, 0xc3, 0x82, 0xaa,
        0x10, 0xba, 0x18, 0xe2, 0x35, 0x7e, 0x71, 0x69,
        0x71, 0xf9, 0x36, 0x2f, 0x2c, 0x2f, 0xe2, 0xa7,
        0x6b, 0xfd, 0x78, 0xdf, 0xec, 0x4e, 0xa9, 0xb5
    };
    static const uint8_t expected_hs[48] = {
        0x03, 0xe6, 0x7b, 0x87, 0x97, 0xb8, 0x86, 0x8b,
        0x32, 0xc7, 0x37, 0xad, 0x09, 0xd2, 0x45, 0x42,
        0x66, 0xb4, 0x7b, 0x82, 0x8f, 0xe8, 0x39, 0x99,
        0x48, 0x45, 0x01, 0xc1, 0xd0, 0xf1, 0x2b, 0xfe,
        0xfd, 0xec, 0xf2, 0x34, 0x1a, 0xb0, 0x55, 0xc5,
        0x0f, 0x8f, 0x81, 0xa4, 0xd9, 0x16, 0x10, 0xdd
    };
    static const uint8_t expected_th[48] = {
        0x64, 0x35, 0x5e, 0x72, 0x05, 0x7c, 0x33, 0xc9,
        0xdf, 0x85, 0x42, 0x19, 0xcf, 0xda, 0xfe, 0x4c,
        0xa4, 0x31, 0xb3, 0x33, 0x45, 0xcf, 0x28, 0x23,
        0xb6, 0xd4, 0x3d, 0xb1, 0x37, 0x06, 0x3f, 0x18,
        0x8d, 0xc9, 0x72, 0x33, 0xc0, 0x5d, 0xec, 0x34,
        0xc1, 0x13, 0xd5, 0x62, 0x54, 0xc8, 0x51, 0x35
    };
    static const uint8_t expected_chts[48] = {
        0x8f, 0x9a, 0x8f, 0x49, 0x13, 0x6e, 0xe3, 0xbb,
        0xfe, 0xe9, 0x48, 0x9a, 0xcd, 0xc0, 0x7d, 0x9e,
        0xe8, 0x2b, 0x82, 0x28, 0x2d, 0x92, 0xf2, 0xc3,
        0xfa, 0x3c, 0xb5, 0xf8, 0x38, 0x6c, 0x86, 0xfb,
        0xb9, 0x0a, 0xf9, 0x95, 0x27, 0x58, 0x40, 0x63,
        0x95, 0xe5, 0x6e, 0xbf, 0x78, 0x96, 0xab, 0xd2
    };
    static const uint8_t expected_shts[48] = {
        0x4a, 0x3c, 0x65, 0xa6, 0x20, 0xec, 0xa8, 0xe6,
        0x2c, 0x13, 0x72, 0xc3, 0xe5, 0x0c, 0x21, 0x1a,
        0x25, 0xd6, 0x8b, 0x39, 0x4c, 0x50, 0xba, 0x46,
        0x18, 0x6b, 0x37, 0x5b, 0x3c, 0x48, 0x9c, 0x11,
        0x45, 0xa1, 0xc4, 0xd0, 0x51, 0x2f, 0x14, 0x6a,
        0x77, 0xe8, 0xac, 0xc0, 0x70, 0x93, 0xa7, 0x81
    };
    static const uint8_t expected_ckey[32] = {
        0x90, 0x3a, 0x65, 0xad, 0x78, 0x84, 0x5a, 0xd0,
        0xcb, 0x90, 0x07, 0xe0, 0x75, 0x80, 0xf4, 0xfe,
        0xce, 0x07, 0x4f, 0x97, 0x2d, 0x8b, 0xa1, 0x0a,
        0x60, 0xda, 0x71, 0x3e, 0xb0, 0x30, 0x4a, 0x82
    };
    static const uint8_t expected_civ[12] = {
        0x53, 0x5d, 0xf7, 0x92, 0x16, 0x6d, 0x54, 0x0c, 0x40, 0x03, 0x1d, 0x5e
    };
    static const uint8_t expected_vd[48] = {
        0x6c, 0xf9, 0x9d, 0xeb, 0xdf, 0x3a, 0xc1, 0xea,
        0x1f, 0x0d, 0xa1, 0x7a, 0x58, 0xe4, 0x4a, 0x1a,
        0x9e, 0x5c, 0x0d, 0x7e, 0x37, 0x69, 0xcc, 0x88,
        0x8b, 0xd0, 0xb5, 0xd7, 0xe1, 0x7f, 0xdf, 0xb2,
        0x6d, 0xe6, 0x06, 0xd8, 0x9b, 0x38, 0x0b, 0xaf,
        0x5c, 0x28, 0xdf, 0x84, 0x72, 0x22, 0x95, 0xbd
    };
    static const uint8_t expected_cak[32] = {
        0x7f, 0xa6, 0x66, 0x77, 0xc6, 0x0d, 0x6e, 0xd9,
        0xf3, 0x0b, 0x9d, 0x4a, 0x6b, 0x28, 0x4c, 0x04,
        0xbb, 0xbd, 0xc4, 0x42, 0xb6, 0x30, 0x8d, 0x75,
        0x27, 0x57, 0x8b, 0xc1, 0x78, 0x7b, 0x17, 0x8b
    };
    static const uint8_t expected_skey[32] = {
        0xff, 0x98, 0x32, 0xe5, 0x1c, 0x7c, 0x46, 0x0d,
        0xcd, 0x2b, 0x74, 0xb0, 0xda, 0x96, 0xa5, 0x3b,
        0xf5, 0x92, 0xd9, 0x33, 0x67, 0x10, 0x5b, 0x64,
        0x95, 0x85, 0xf2, 0xd3, 0xf7, 0x85, 0x38, 0x2d
    };
    static const uint8_t expected_siv[12] = {
        0x0f, 0xa7, 0x0d, 0x6e, 0x1a, 0x5b, 0x2d, 0x67, 0x52, 0x72, 0xad, 0x44
    };
    static const uint8_t expected_cai[12] = {
        0x18, 0xdc, 0xb5, 0x50, 0xff, 0x3d, 0xb6, 0xfa, 0x8c, 0xba, 0x3e, 0x96
    };
    static const uint8_t expected_sak[32] = {
        0xe6, 0x6e, 0xd4, 0x0e, 0xed, 0xd0, 0xb1, 0xa6,
        0x7e, 0xaa, 0x9d, 0x9b, 0xfd, 0x82, 0x3a, 0x88,
        0xf4, 0x1e, 0x6f, 0x47, 0xd4, 0x5f, 0x8f, 0x19,
        0xb6, 0x3b, 0x9c, 0xa0, 0xc6, 0x4f, 0x23, 0x6e
    };
    static const uint8_t expected_sai[12] = {
        0x18, 0xa4, 0xbb, 0xb8, 0x50, 0x92, 0x3c, 0xa5, 0x29, 0x31, 0xb9, 0x45
    };
    uint8_t empty[48], early[48], derived[48], hs[48], th[48];
    uint8_t chts[48], shts[48], ckey[32], civ[12], skey[32], siv[12];
    uint8_t fin[48], vd[48], master[48], cats[48], sats[48];
    uint8_t cak[32], cai[12], sak[32], sai[12];
    struct tls_hash_context hc;
    struct tls_hmac_context hm;
    bool ok = true;

    ok &= tls_hash_context_init(&hc, TLS_HASH_SHA384);
    tls_hash_digest(&hc, empty);
    ok &= tls_hkdf_extract(TLS_HASH_SHA384, NULL, 0, NULL, 48, early);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, early, 48,
                                "derived", 7, empty, 48, derived, 48);
    ok &= tls_hkdf_extract(TLS_HASH_SHA384, derived, 48, ecdhe, 32, hs);
    ok &= tls_hash_context_init(&hc, TLS_HASH_SHA384);
    tls_hash_update(&hc, transcript, sizeof(transcript) - 1);
    tls_hash_digest(&hc, th);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, hs, 48,
                                "c hs traffic", 12, th, 48, chts, 48);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, hs, 48,
                                "s hs traffic", 12, th, 48, shts, 48);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, chts, 48,
                                "key", 3, NULL, 0, ckey, 32);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, chts, 48,
                                "iv", 2, NULL, 0, civ, 12);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, shts, 48,
                                "key", 3, NULL, 0, skey, 32);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, shts, 48,
                                "iv", 2, NULL, 0, siv, 12);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, shts, 48,
                                "finished", 8, NULL, 0, fin, 48);
    ok &= tls_hmac_context_init(&hm, TLS_HASH_SHA384, fin, 48);
    tls_hmac_update(&hm, th, 48);
    tls_hmac_digest(&hm, vd);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, hs, 48,
                                "derived", 7, empty, 48, derived, 48);
    ok &= tls_hkdf_extract(TLS_HASH_SHA384, derived, 48, NULL, 48, master);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, master, 48,
                                "c ap traffic", 12, th, 48, cats, 48);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, master, 48,
                                "s ap traffic", 12, th, 48, sats, 48);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, cats, 48,
                                "key", 3, NULL, 0, cak, 32);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, cats, 48,
                                "iv", 2, NULL, 0, cai, 12);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, sats, 48,
                                "key", 3, NULL, 0, sak, 32);
    ok &= tls_hkdf_expand_label(TLS_HASH_SHA384, sats, 48,
                                "iv", 2, NULL, 0, sai, 12);

    ok &= memcmp(early, expected_early, 48) == 0;
    ok &= memcmp(hs, expected_hs, 48) == 0;
    ok &= memcmp(th, expected_th, 48) == 0;
    ok &= memcmp(chts, expected_chts, 48) == 0;
    ok &= memcmp(shts, expected_shts, 48) == 0;
    ok &= memcmp(ckey, expected_ckey, 32) == 0;
    ok &= memcmp(civ, expected_civ, 12) == 0;
    ok &= memcmp(vd, expected_vd, 48) == 0;
    ok &= memcmp(cak, expected_cak, 32) == 0;
    ok &= memcmp(skey, expected_skey, 32) == 0;
    ok &= memcmp(siv, expected_siv, 12) == 0;
    ok &= memcmp(cai, expected_cai, 12) == 0;
    ok &= memcmp(sak, expected_sak, 32) == 0;
    ok &= memcmp(sai, expected_sai, 12) == 0;
    return ok;
}

/* Run one test on its own cleared screen, printing only "success" or
 * "fail" so each screen's VRAM CRC is a stable, independent checkpoint --
 * unaffected by any other test's result or by future tests added here. */
static void run_test_screen(bool result) {
    os_ClrHome();
    printf(result ? "success" : "fail");
    os_GetKey();
}

int main(void) {
    if (!lwip_start()) return 1;

    run_test_screen(test_hkdf_rfc5869_case1());
    run_test_screen(test_hkdf_rfc5869_case2());
    run_test_screen(test_hkdf_rfc5869_case3());
    run_test_screen(test_hkdf_expand_label());
    run_test_screen(test_tls13_sha384_key_schedule());

    {
        const uint16_t samples = 5;
        const uint16_t lens[2] = {32, 256};
        struct timing_group groups[2] = {0};
        uint8_t buf[256];
        uint32_t ticks[5];

        for (uint8_t g = 0; g < 2; g++)
        {
            uint16_t len = lens[g];
            for (uint16_t i = 0; i < samples; i++)
            {
                for (uint16_t j = 0; j < len; j++)
                    buf[j] = (uint8_t)(j + i);
                ticks[i] = time_hkdf(buf, len);
            }
            groups[g].len = len;
            groups[g].samples = samples;
            compute_stats(ticks, samples, &groups[g]);
        }

        printf("timing len=%u dev=%u.%02u%%\n",
               groups[0].len,
               groups[0].pct_x100 / 100,
               groups[0].pct_x100 % 100);
        printf("timing len=%u dev=%u.%02u%%",
               groups[1].len,
               groups[1].pct_x100 / 100,
               groups[1].pct_x100 % 100);
        os_GetKey();
        os_ClrHome();
    }

    return 0;
}
