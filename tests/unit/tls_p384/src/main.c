/**
 * @file main.c
 * @brief P-384 (secp384r1) unit tests — keygen, ECDH, deterministic ECDSA,
 *        input rejection, and timing.
 *
 * Reference values were generated with an independent pure-Python P-384
 * implementation (affine point arithmetic + RFC 6979 HMAC-SHA-384).
 */

#include <stdbool.h>
#include <stdint.h>
#include <stdio.h>
#include <string.h>
#include <time.h>
#include <ti/screen.h>
#include <ti/getkey.h>

#include <lwip.h>
#include <lwip/cryptography/p384.h>

static const uint8_t priv_one[48] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,
};
static const uint8_t priv_nm1[48] = {
    0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,
    0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,
    0xc7,0x63,0x4d,0x81,0xf4,0x37,0x2d,0xdf,0x58,0x1a,0x0d,0xb2,
    0x48,0xb0,0xa7,0x7a,0xec,0xec,0x19,0x6a,0xcc,0xc5,0x29,0x72,
};
static const uint8_t priv_a[48] = {
    0x77,0x22,0x17,0x6b,0xb2,0x40,0xc7,0x97,0x43,0xe8,0x0b,0xaa,
    0x83,0x9b,0xa5,0x72,0xcf,0x5a,0xc4,0xce,0xa0,0x12,0xc3,0x90,
    0x19,0x2c,0xe2,0x4f,0x12,0x1b,0x37,0xe7,0xd2,0x64,0xba,0x13,
    0x4d,0x38,0x7e,0xbf,0x45,0x45,0xbd,0x5a,0xd2,0xa1,0xb7,0xfd,
};
static const uint8_t priv_npriv_a[48] = {
    0x88,0xdd,0xe8,0x94,0x4d,0xbf,0x38,0x68,0xbc,0x17,0xf4,0x55,
    0x7c,0x64,0x5a,0x8d,0x30,0xa5,0x3b,0x31,0x5f,0xed,0x3c,0x6f,
    0xae,0x36,0x6b,0x32,0xe2,0x1b,0xf5,0xf7,0x85,0xb5,0x53,0x9e,
    0xfb,0x78,0x28,0xbb,0xa7,0xa6,0x5c,0x0f,0xfa,0x23,0x71,0x76,
};
static const uint8_t priv_b[48] = {
    0x9a,0x97,0xec,0xdf,0x93,0x93,0x3b,0xa4,0xf9,0x2c,0xa1,0xb0,
    0xde,0x34,0xf5,0xc0,0xe8,0x54,0x33,0xdf,0x47,0x73,0x95,0x83,
    0xf9,0x6b,0x65,0x15,0x56,0x16,0x5a,0x2f,0xfc,0xe4,0x4b,0x7a,
    0x47,0x83,0x59,0x46,0x20,0xcb,0x88,0x1f,0x66,0xab,0x1d,0xfe,
};
static const uint8_t pub_one[97] = {
    0x04,0xaa,0x87,0xca,0x22,0xbe,0x8b,0x05,0x37,0x8e,0xb1,0xc7,
    0x1e,0xf3,0x20,0xad,0x74,0x6e,0x1d,0x3b,0x62,0x8b,0xa7,0x9b,
    0x98,0x59,0xf7,0x41,0xe0,0x82,0x54,0x2a,0x38,0x55,0x02,0xf2,
    0x5d,0xbf,0x55,0x29,0x6c,0x3a,0x54,0x5e,0x38,0x72,0x76,0x0a,
    0xb7,0x36,0x17,0xde,0x4a,0x96,0x26,0x2c,0x6f,0x5d,0x9e,0x98,
    0xbf,0x92,0x92,0xdc,0x29,0xf8,0xf4,0x1d,0xbd,0x28,0x9a,0x14,
    0x7c,0xe9,0xda,0x31,0x13,0xb5,0xf0,0xb8,0xc0,0x0a,0x60,0xb1,
    0xce,0x1d,0x7e,0x81,0x9d,0x7a,0x43,0x1d,0x7c,0x90,0xea,0x0e,
    0x5f,
};
static const uint8_t pub_nm1[97] = {
    0x04,0xaa,0x87,0xca,0x22,0xbe,0x8b,0x05,0x37,0x8e,0xb1,0xc7,
    0x1e,0xf3,0x20,0xad,0x74,0x6e,0x1d,0x3b,0x62,0x8b,0xa7,0x9b,
    0x98,0x59,0xf7,0x41,0xe0,0x82,0x54,0x2a,0x38,0x55,0x02,0xf2,
    0x5d,0xbf,0x55,0x29,0x6c,0x3a,0x54,0x5e,0x38,0x72,0x76,0x0a,
    0xb7,0xc9,0xe8,0x21,0xb5,0x69,0xd9,0xd3,0x90,0xa2,0x61,0x67,
    0x40,0x6d,0x6d,0x23,0xd6,0x07,0x0b,0xe2,0x42,0xd7,0x65,0xeb,
    0x83,0x16,0x25,0xce,0xec,0x4a,0x0f,0x47,0x3e,0xf5,0x9f,0x4e,
    0x30,0xe2,0x81,0x7e,0x62,0x85,0xbc,0xe2,0x84,0x6f,0x15,0xf1,
    0xa0,
};
static const uint8_t pub_a[97] = {
    0x04,0x5c,0x04,0x3b,0x9b,0x85,0xbb,0x95,0x9d,0x6d,0xd5,0x93,
    0xc6,0xb2,0x3d,0xba,0x44,0x26,0x87,0xc1,0xd5,0x69,0xaf,0xb2,
    0x1d,0x37,0xbc,0xc4,0x15,0x4a,0xba,0x1b,0xed,0x19,0x6e,0xa7,
    0x48,0x35,0x15,0x17,0x56,0x52,0x39,0x36,0xa1,0x07,0x3a,0x30,
    0x12,0x1a,0x19,0x05,0xb1,0xd4,0x68,0xef,0x37,0xe7,0x0b,0x01,
    0x5d,0x57,0x11,0x35,0xe6,0xa6,0x00,0x70,0x9a,0xe4,0x75,0x6c,
    0xa7,0x9c,0xa6,0xb6,0xef,0x21,0x51,0x23,0x77,0xc0,0x16,0x11,
    0xcc,0x2d,0xe1,0x12,0xf6,0x7e,0x0e,0x7e,0x87,0x9e,0x83,0x28,
    0x65,
};
static const uint8_t pub_b[97] = {
    0x04,0xf8,0x06,0xca,0x64,0x89,0x5f,0xb5,0x2c,0xb6,0x7d,0x02,
    0x22,0x38,0x35,0xe2,0x40,0x14,0xf2,0x93,0x20,0x3d,0xcb,0x7a,
    0x8d,0x9a,0x48,0x76,0x24,0x40,0xe2,0xd2,0x67,0xb4,0xda,0x02,
    0xfe,0x50,0xbe,0x55,0x00,0x88,0x46,0x46,0xe9,0x8f,0x24,0x88,
    0x19,0xec,0x96,0x0f,0x07,0x95,0xe1,0xd0,0xc7,0xbc,0x6c,0xe2,
    0xee,0xbf,0xd4,0x65,0xe6,0xdb,0xbc,0x57,0x70,0xb3,0xba,0x95,
    0x9c,0x6e,0xb1,0x05,0xe0,0x88,0xdf,0x99,0x1b,0x51,0x5c,0xd7,
    0xb3,0x63,0xf7,0x35,0xf3,0x12,0xe9,0x51,0x1c,0x27,0xd5,0x09,
    0x5b,
};
static const uint8_t pub_npriv_a[97] = {
    0x04,0x5c,0x04,0x3b,0x9b,0x85,0xbb,0x95,0x9d,0x6d,0xd5,0x93,
    0xc6,0xb2,0x3d,0xba,0x44,0x26,0x87,0xc1,0xd5,0x69,0xaf,0xb2,
    0x1d,0x37,0xbc,0xc4,0x15,0x4a,0xba,0x1b,0xed,0x19,0x6e,0xa7,
    0x48,0x35,0x15,0x17,0x56,0x52,0x39,0x36,0xa1,0x07,0x3a,0x30,
    0x12,0xe5,0xe6,0xfa,0x4e,0x2b,0x97,0x10,0xc8,0x18,0xf4,0xfe,
    0xa2,0xa8,0xee,0xca,0x19,0x59,0xff,0x8f,0x65,0x1b,0x8a,0x93,
    0x58,0x63,0x59,0x49,0x10,0xde,0xae,0xdc,0x87,0x3f,0xe9,0xee,
    0x32,0xd2,0x1e,0xed,0x09,0x81,0xf1,0x81,0x79,0x61,0x7c,0xd7,
    0x9a,
};
static const uint8_t ecdh_ab[48] = {
    0x37,0x2d,0x88,0x86,0x3c,0x27,0xfe,0x9d,0x8a,0x23,0x21,0xa0,
    0x7f,0x52,0x1c,0x27,0xdb,0xa7,0xe8,0xdc,0x77,0x4f,0xae,0xad,
    0xf5,0x38,0xe2,0x2b,0x61,0x03,0x0a,0x6c,0x47,0x37,0x53,0x8a,
    0x42,0xa9,0x9a,0x5d,0x82,0xe0,0xc3,0xe9,0x49,0xac,0x8b,0xcb,
};
static const uint8_t hash1[48] = {
    0x9a,0x90,0x83,0x50,0x5b,0xc9,0x22,0x76,0xae,0xc4,0xbe,0x31,
    0x26,0x96,0xef,0x7b,0xf3,0xbf,0x60,0x3f,0x4b,0xbd,0x38,0x11,
    0x96,0xa0,0x29,0xf3,0x40,0x58,0x53,0x12,0x31,0x3b,0xca,0x4a,
    0x9b,0x5b,0x89,0x0e,0xfe,0xe4,0x2c,0x77,0xb1,0xee,0x25,0xfe,
};
static const uint8_t hash2[48] = {
    0x53,0xd8,0x72,0x1b,0xa2,0x29,0xb1,0xda,0xed,0x0a,0x0b,0x9f,
    0xf5,0xfe,0xeb,0x40,0xf0,0xa2,0xab,0xf2,0x11,0xfd,0x32,0x63,
    0xa1,0xf6,0x80,0x49,0x8e,0xea,0x44,0x7c,0xd2,0x97,0x0a,0xd5,
    0xca,0x0a,0xe5,0xa3,0x51,0x5a,0x73,0xe3,0xe7,0x2e,0xd4,0x11,
};
static const uint8_t hash3[48] = {
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};
static const uint8_t sig_a_h1[96] = {
    0xf3,0xab,0x00,0x11,0x0d,0x55,0x47,0x08,0x94,0x54,0x8c,0x60,
    0xd0,0xee,0xd6,0xc8,0xdf,0x74,0x2b,0x36,0x70,0xf1,0x22,0xec,
    0x76,0x73,0x88,0xf1,0xa8,0x76,0x17,0x56,0x68,0x04,0x3f,0xec,
    0x27,0x00,0x2b,0x61,0xd9,0x60,0xf2,0x90,0xc7,0x6e,0xb9,0xfa,
    0x62,0x2d,0x8d,0xf5,0xdb,0xd5,0x80,0xc9,0x63,0xcc,0x67,0x17,
    0xa2,0x07,0x3a,0x7d,0x4d,0xcc,0xb1,0xbb,0xf3,0x27,0xbe,0xff,
    0x4f,0xe6,0xc5,0x46,0x1a,0x69,0xf2,0xaa,0x4a,0xa2,0x30,0x91,
    0xd6,0x50,0xd6,0x46,0x8a,0x18,0xf7,0x84,0xd0,0x74,0x35,0xbf,
};
static const uint8_t sig_b_h2[96] = {
    0xd0,0xd0,0xa1,0x0e,0x20,0x6e,0x4e,0xc6,0x39,0x88,0x4e,0x07,
    0xef,0xb6,0x8d,0xea,0x01,0x62,0xfd,0x0c,0xfd,0x7a,0x98,0x45,
    0x0c,0x98,0x75,0xe4,0x21,0xef,0x18,0xf2,0x39,0xd3,0x7f,0xec,
    0x48,0xe3,0x69,0x11,0x5d,0xef,0x16,0x76,0x5a,0xc2,0x75,0x80,
    0xd1,0xe0,0x20,0x20,0xcf,0x19,0x60,0xaf,0x4c,0x7d,0x79,0xb5,
    0x78,0x09,0xb2,0x6f,0x00,0x45,0x56,0x51,0x5e,0x8b,0x22,0x38,
    0x2d,0xb9,0x37,0xb4,0xd3,0xce,0xe6,0xab,0x96,0x53,0xa4,0xdf,
    0x5f,0x55,0x8e,0x10,0xc5,0x1e,0xce,0xf8,0x76,0xef,0xeb,0x9d,
};
static const uint8_t sig_a_h3[96] = {
    0x5a,0x76,0x71,0xd1,0x97,0xd0,0xc3,0x94,0x49,0xb2,0x40,0xc3,
    0xcf,0x46,0x20,0xe9,0xd2,0xed,0xcb,0xf6,0x9f,0x82,0xe6,0x7f,
    0xac,0xdb,0x16,0x2f,0x76,0xa5,0x82,0xc4,0x5d,0x29,0x39,0x13,
    0x38,0x16,0xfd,0x06,0x98,0x23,0x50,0xe1,0x2a,0x71,0x04,0x8f,
    0xe3,0x01,0x17,0xd0,0x18,0x41,0x19,0xea,0xa0,0x52,0x2a,0x22,
    0x9d,0xc5,0xc5,0x68,0x97,0x74,0x45,0xb8,0xe6,0x7a,0x62,0x4d,
    0x79,0x59,0x78,0xc0,0x3e,0x7f,0x66,0x59,0x39,0x59,0x7c,0x43,
    0x6f,0xec,0xac,0xf1,0x78,0x57,0x60,0xd7,0x27,0x40,0xc3,0xfd,
};
static const uint8_t n_bytes[48] = {
    0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,
    0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,
    0xc7,0x63,0x4d,0x81,0xf4,0x37,0x2d,0xdf,0x58,0x1a,0x0d,0xb2,
    0x48,0xb0,0xa7,0x7a,0xec,0xec,0x19,0x6a,0xcc,0xc5,0x29,0x73,
};
static const uint8_t p_bytes[48] = {
    0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,
    0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,
    0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xfe,0xff,0xff,0xff,0xff,
    0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xff,0xff,0xff,0xff,
};

static void report(int ok)
{
    if (ok)
        printf("success");
    else
        printf("failed");
}

static bool test_pub_one(void)
{
    uint8_t pub[97];
    return tls_p384_publickey(pub, priv_one) && memcmp(pub, pub_one, 97) == 0;
}

static bool test_pub_nm1(void)
{
    uint8_t pub[97];
    return tls_p384_publickey(pub, priv_nm1) && memcmp(pub, pub_nm1, 97) == 0;
}

static bool test_pub_a(void)
{
    uint8_t pub[97];
    return tls_p384_publickey(pub, priv_a) && memcmp(pub, pub_a, 97) == 0;
}

static bool test_pub_a_neg(void)
{
    uint8_t pub[97];
    if (!tls_p384_publickey(pub, priv_npriv_a)) return false;
    if (memcmp(pub, pub_npriv_a, 97) != 0) return false;
    /* x is unchanged; y1 + y2 == p */
    if (memcmp(pub + 1, pub_a + 1, 48) != 0) return false;
    return true;
}

static bool test_ecdh_ab(void)
{
    uint8_t ss[48];
    return tls_p384_secret(ss, priv_a, pub_b) && memcmp(ss, ecdh_ab, 48) == 0;
}

static bool test_ecdh_ba(void)
{
    uint8_t ss[48];
    return tls_p384_secret(ss, priv_b, pub_a) && memcmp(ss, ecdh_ab, 48) == 0;
}

static bool test_sign_a(void)
{
    uint8_t sig[96], sig2[96];
    if (!tls_p384_sign(sig, hash1, priv_a)) return false;
    if (memcmp(sig, sig_a_h1, 96) != 0) return false;
    /* RFC 6979 is deterministic: sign again, same r/s. */
    if (!tls_p384_sign(sig2, hash1, priv_a)) return false;
    return memcmp(sig, sig2, 96) == 0;
}

static bool test_verify_a(void)
{
    return tls_p384_verify(sig_a_h1, hash1, pub_a);
}

static bool test_sign_b(void)
{
    uint8_t sig[96];
    if (!tls_p384_sign(sig, hash2, priv_b)) return false;
    if (memcmp(sig, sig_b_h2, 96) != 0) return false;
    return tls_p384_verify(sig, hash2, pub_b);
}

static bool test_sign_zero_hash(void)
{
    uint8_t sig[96];
    if (!tls_p384_sign(sig, hash3, priv_a)) return false;
    if (memcmp(sig, sig_a_h3, 96) != 0) return false;
    return tls_p384_verify(sig, hash3, pub_a);
}

static bool test_reject_bad(void)
{
    uint8_t pub[97], bad_sig[96], bad_pub[97], ss[48];
    bool ok = true;

    if (!tls_p384_publickey(pub, priv_a)) return false;
    memcpy(bad_sig, sig_a_h1, 96);
    bad_sig[5] ^= 0x10;
    ok = ok && !tls_p384_verify(bad_sig, hash1, pub);
    ok = ok && !tls_p384_verify(sig_a_h1, hash2, pub);

    memcpy(bad_pub, pub_a, 97);
    bad_pub[96] ^= 0x01;
    ok = ok && !tls_p384_secret(ss, priv_a, bad_pub);
    ok = ok && !tls_p384_verify(sig_a_h1, hash1, bad_pub);

    memcpy(bad_pub, pub_a, 97);
    bad_pub[0] = 0x02;
    ok = ok && !tls_p384_secret(ss, priv_a, bad_pub);

    memcpy(bad_pub, pub_a, 97);
    memcpy(bad_pub + 1, p_bytes, 48);
    ok = ok && !tls_p384_secret(ss, priv_a, bad_pub);

    memset(bad_pub, 0, 97);
    bad_pub[0] = 0x04;
    ok = ok && !tls_p384_secret(ss, priv_a, bad_pub);
    return ok;
}

static bool test_reject_range(void)
{
    uint8_t pub[97], bad_sig[96];
    bool ok = true;

    if (!tls_p384_publickey(pub, priv_a)) return false;
    memset(bad_sig, 0, 96);
    memcpy(bad_sig + 48, sig_a_h1 + 48, 48);
    ok = ok && !tls_p384_verify(bad_sig, hash1, pub);

    memcpy(bad_sig, sig_a_h1, 48);
    memset(bad_sig + 48, 0, 48);
    ok = ok && !tls_p384_verify(bad_sig, hash1, pub);

    memcpy(bad_sig, n_bytes, 48);
    memcpy(bad_sig + 48, sig_a_h1 + 48, 48);
    ok = ok && !tls_p384_verify(bad_sig, hash1, pub);

    memcpy(bad_sig, sig_a_h1, 48);
    memcpy(bad_sig + 48, n_bytes, 48);
    ok = ok && !tls_p384_verify(bad_sig, hash1, pub);
    return ok;
}


int main(void)
{
    bool ok;
    uint8_t ss[48];

    if (!lwip_start()) return 1;

    os_ClrHome();
    ok = test_pub_one();
    report(ok);
    os_GetKey();
    os_ClrHome();

    ok = test_pub_nm1();
    report(ok);
    os_GetKey();
    os_ClrHome();

    ok = test_pub_a();
    report(ok);
    os_GetKey();
    os_ClrHome();

    ok = test_ecdh_ab();
    report(ok);
    os_GetKey();
    os_ClrHome();

    ok = test_ecdh_ba();
    report(ok);
    os_GetKey();
    os_ClrHome();

    ok = test_sign_a();
    report(ok);
    os_GetKey();
    os_ClrHome();

    ok = test_verify_a();
    report(ok);
    os_GetKey();
    os_ClrHome();

    ok = test_sign_b();
    report(ok);
    os_GetKey();
    os_ClrHome();

    ok = test_sign_zero_hash();
    report(ok);
    os_GetKey();
    os_ClrHome();

    ok = test_reject_bad();
    report(ok);
    os_GetKey();
    os_ClrHome();

    ok = test_reject_range();
    report(ok);
    os_GetKey();
    os_ClrHome();

    ok = test_pub_a_neg();
    report(ok);
    os_GetKey();
    os_ClrHome();

    memset(ss, 0, sizeof(ss));

    /* hash 14: timing screen — ops run here, screen ends with "success" */
    {
        uint8_t pub[97], sig[96];
        clock_t t0;
        uint32_t tpk, tss, tsg, tvf;
        t0 = clock(); (void)tls_p384_publickey(pub, priv_a); tpk = (uint32_t)(clock() - t0);
        t0 = clock(); (void)tls_p384_secret(ss, priv_a, pub_b); tss = (uint32_t)(clock() - t0);
        t0 = clock(); (void)tls_p384_sign(sig, hash1, priv_a); tsg = (uint32_t)(clock() - t0);
        t0 = clock(); (void)tls_p384_verify(sig, hash1, pub); tvf = (uint32_t)(clock() - t0);
        printf("pk %lu.%03lu s\n", (unsigned long)(tpk / 32768u), (unsigned long)((tpk % 32768u) * 1000u / 32768u));
        printf("ss %lu.%03lu s\n", (unsigned long)(tss / 32768u), (unsigned long)((tss % 32768u) * 1000u / 32768u));
        printf("sg %lu.%03lu s\n", (unsigned long)(tsg / 32768u), (unsigned long)((tsg % 32768u) * 1000u / 32768u));
        printf("vf %lu.%03lu s\n", (unsigned long)(tvf / 32768u), (unsigned long)((tvf % 32768u) * 1000u / 32768u));
        printf("success");
    }
    os_GetKey();
    os_ClrHome();

    return 0;
}
