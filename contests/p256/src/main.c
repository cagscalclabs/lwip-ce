/*
 * P-256 contest test harness.
 *
 * ECDHE vectors: RFC 5903 §8.1
 * ECDSA vectors: RFC 6979 Appendix A.2.5 (P-256 / SHA-256, deterministic k)
 *                NIST CAVP ECDSA test vectors (additional sign/verify pairs)
 *
 * The contestant must implement the four functions declared in p256.h.
 * This file must not be modified.
 */

#include <stdbool.h>
#include <stdint.h>
#include <string.h>
#include <stdio.h>
#include <stdlib.h>
#include <time.h>

#include <ti/screen.h>
#include <ti/getkey.h>

#include "p256.h"

/* =========================================================================
 * Helpers
 * ========================================================================= */

static void print_result(const char *label, bool pass)
{
    printf("%-22s %s\n", label, pass ? "PASS" : "FAIL");
}

/* =========================================================================
 * ECDHE tests  (RFC 5903 §8.1 — P-256 Diffie-Hellman)
 * =========================================================================
 *
 * Party i has private scalar i_priv and public key i_pub.
 * Both parties must derive the same shared secret (X coordinate).
 */

/* --- RFC 5903 §8.1: initiator pubkey --- */
static bool ecdhe_rfc5903_init_pubkey(void)
{
    const uint8_t priv[32] = {
        0xC8, 0x8F, 0x01, 0xF5, 0x10, 0xD9, 0xAC, 0x3F,
        0x70, 0xA2, 0x92, 0xDA, 0xA2, 0x31, 0x6D, 0xE5,
        0x44, 0xE9, 0xAA, 0xB8, 0xAF, 0xE8, 0x40, 0x49,
        0xC6, 0x2A, 0x9C, 0x57, 0x86, 0x2D, 0x14, 0x33
    };
    const uint8_t exp_x[32] = {
        0xDA, 0xD0, 0xB6, 0x53, 0x94, 0x22, 0x1C, 0xF9,
        0xB0, 0x51, 0xE1, 0xFE, 0xCA, 0x57, 0x87, 0xD0,
        0x98, 0xDF, 0xE6, 0x37, 0xFC, 0x90, 0xB9, 0xEF,
        0x94, 0x5D, 0x0C, 0x37, 0x72, 0x58, 0x11, 0x80
    };
    const uint8_t exp_y[32] = {
        0x52, 0x71, 0xA0, 0x46, 0x1C, 0xDB, 0x82, 0x52,
        0xD6, 0x1F, 0x1C, 0x45, 0x6F, 0xA3, 0xE5, 0x9A,
        0xB1, 0xF4, 0x5B, 0x33, 0xAC, 0xCF, 0x5F, 0x58,
        0x38, 0x9E, 0x05, 0x77, 0xB8, 0x99, 0x0B, 0xB3
    };

    uint8_t pub[65];
    if (!tls_p256_publickey(pub, priv))
        return false;
    if (pub[0] != 0x04)
        return false;
    return memcmp(pub + 1,      exp_x, 32) == 0 &&
           memcmp(pub + 1 + 32, exp_y, 32) == 0;
}

/* --- RFC 5903 §8.1: responder pubkey --- */
static bool ecdhe_rfc5903_resp_pubkey(void)
{
    const uint8_t priv[32] = {
        0xC6, 0xEF, 0x9C, 0x5D, 0x78, 0xAE, 0x01, 0x2A,
        0x01, 0x11, 0x64, 0xAC, 0xB3, 0x97, 0xCE, 0x20,
        0x88, 0x58, 0x5D, 0xBC, 0x89, 0xAF, 0xB0, 0x4E,
        0xBA, 0xB8, 0x1D, 0x7E, 0xAD, 0xEE, 0x28, 0x36
    };
    const uint8_t exp_x[32] = {
        0xD1, 0x2D, 0xFB, 0x52, 0x89, 0xC8, 0xD4, 0xF8,
        0x12, 0x08, 0xB7, 0x02, 0x70, 0x39, 0x8C, 0x34,
        0x22, 0x96, 0x97, 0x0A, 0x0B, 0xCC, 0xB7, 0x4C,
        0x73, 0x6F, 0xC7, 0x55, 0x44, 0x94, 0xBF, 0x63
    };
    const uint8_t exp_y[32] = {
        0x56, 0x95, 0x07, 0x03, 0x10, 0xD7, 0xD3, 0x35,
        0x7D, 0x2F, 0xB9, 0x51, 0x35, 0x9C, 0xAB, 0xE0,
        0x17, 0x74, 0x24, 0x24, 0x32, 0x27, 0xEA, 0xF7,
        0x9A, 0x55, 0x59, 0x06, 0x5F, 0xA6, 0x41, 0x39
    };

    uint8_t pub[65];
    if (!tls_p256_publickey(pub, priv))
        return false;
    if (pub[0] != 0x04)
        return false;
    return memcmp(pub + 1,      exp_x, 32) == 0 &&
           memcmp(pub + 1 + 32, exp_y, 32) == 0;
}

/* --- RFC 5903 §8.1: shared secret (initiator computes i_priv * r_pub) --- */
static bool ecdhe_rfc5903_secret_init(void)
{
    const uint8_t i_priv[32] = {
        0xC8, 0x8F, 0x01, 0xF5, 0x10, 0xD9, 0xAC, 0x3F,
        0x70, 0xA2, 0x92, 0xDA, 0xA2, 0x31, 0x6D, 0xE5,
        0x44, 0xE9, 0xAA, 0xB8, 0xAF, 0xE8, 0x40, 0x49,
        0xC6, 0x2A, 0x9C, 0x57, 0x86, 0x2D, 0x14, 0x33
    };
    const uint8_t r_pub[65] = {
        0x04,
        0xD1, 0x2D, 0xFB, 0x52, 0x89, 0xC8, 0xD4, 0xF8,
        0x12, 0x08, 0xB7, 0x02, 0x70, 0x39, 0x8C, 0x34,
        0x22, 0x96, 0x97, 0x0A, 0x0B, 0xCC, 0xB7, 0x4C,
        0x73, 0x6F, 0xC7, 0x55, 0x44, 0x94, 0xBF, 0x63,
        0x56, 0x95, 0x07, 0x03, 0x10, 0xD7, 0xD3, 0x35,
        0x7D, 0x2F, 0xB9, 0x51, 0x35, 0x9C, 0xAB, 0xE0,
        0x17, 0x74, 0x24, 0x24, 0x32, 0x27, 0xEA, 0xF7,
        0x9A, 0x55, 0x59, 0x06, 0x5F, 0xA6, 0x41, 0x39
    };
    const uint8_t expected[32] = {
        0xD6, 0x84, 0x0F, 0x6B, 0x42, 0xF6, 0xED, 0xAF,
        0xD1, 0x31, 0x16, 0xE0, 0xE1, 0x25, 0x65, 0x20,
        0x2F, 0xEF, 0x8E, 0x9E, 0xCE, 0x7D, 0xCE, 0x03,
        0x81, 0x24, 0x64, 0xD0, 0x4B, 0x94, 0x42, 0xDE
    };

    uint8_t secret[32];
    if (!tls_p256_secret(secret, i_priv, r_pub))
        return false;
    return memcmp(secret, expected, 32) == 0;
}

/* --- RFC 5903 §8.1: shared secret (responder computes r_priv * i_pub) --- */
static bool ecdhe_rfc5903_secret_resp(void)
{
    const uint8_t r_priv[32] = {
        0xC6, 0xEF, 0x9C, 0x5D, 0x78, 0xAE, 0x01, 0x2A,
        0x01, 0x11, 0x64, 0xAC, 0xB3, 0x97, 0xCE, 0x20,
        0x88, 0x58, 0x5D, 0xBC, 0x89, 0xAF, 0xB0, 0x4E,
        0xBA, 0xB8, 0x1D, 0x7E, 0xAD, 0xEE, 0x28, 0x36
    };
    const uint8_t i_pub[65] = {
        0x04,
        0xDA, 0xD0, 0xB6, 0x53, 0x94, 0x22, 0x1C, 0xF9,
        0xB0, 0x51, 0xE1, 0xFE, 0xCA, 0x57, 0x87, 0xD0,
        0x98, 0xDF, 0xE6, 0x37, 0xFC, 0x90, 0xB9, 0xEF,
        0x94, 0x5D, 0x0C, 0x37, 0x72, 0x58, 0x11, 0x80,
        0x52, 0x71, 0xA0, 0x46, 0x1C, 0xDB, 0x82, 0x52,
        0xD6, 0x1F, 0x1C, 0x45, 0x6F, 0xA3, 0xE5, 0x9A,
        0xB1, 0xF4, 0x5B, 0x33, 0xAC, 0xCF, 0x5F, 0x58,
        0x38, 0x9E, 0x05, 0x77, 0xB8, 0x99, 0x0B, 0xB3
    };
    const uint8_t expected[32] = {
        0xD6, 0x84, 0x0F, 0x6B, 0x42, 0xF6, 0xED, 0xAF,
        0xD1, 0x31, 0x16, 0xE0, 0xE1, 0x25, 0x65, 0x20,
        0x2F, 0xEF, 0x8E, 0x9E, 0xCE, 0x7D, 0xCE, 0x03,
        0x81, 0x24, 0x64, 0xD0, 0x4B, 0x94, 0x42, 0xDE
    };

    uint8_t secret[32];
    if (!tls_p256_secret(secret, r_priv, i_pub))
        return false;
    return memcmp(secret, expected, 32) == 0;
}

/* =========================================================================
 * ECDSA tests  (RFC 6979 Appendix A.2.5 — P-256 / SHA-256)
 * =========================================================================
 *
 * Private key d and public key Q are fixed across all sign tests.
 * If the contestant uses deterministic k (RFC 6979), the exact (r,s) is
 * checked.  The round-trip verify tests apply regardless of k strategy.
 */

static const uint8_t rfc6979_priv[32] = {
    0xC9, 0xAF, 0xA9, 0xD8, 0x45, 0xBA, 0x75, 0x16,
    0x6B, 0x5C, 0x21, 0x57, 0x67, 0xB1, 0xD6, 0x93,
    0x4E, 0x50, 0xC3, 0xDB, 0x36, 0xE8, 0x9B, 0x12,
    0x7B, 0x8A, 0x62, 0x2B, 0x12, 0x0F, 0x67, 0x21
};

static const uint8_t rfc6979_pub[65] = {
    0x04,
    0x60, 0xFE, 0xD4, 0xBA, 0x25, 0x5A, 0x9D, 0x31,
    0xC9, 0x61, 0xEB, 0x74, 0xC6, 0x35, 0x6D, 0x68,
    0xC0, 0x49, 0xB8, 0x92, 0x3B, 0x61, 0xFA, 0x6C,
    0xE6, 0x69, 0x62, 0x2E, 0x60, 0xF2, 0x9F, 0xB6,
    0x79, 0x03, 0xFE, 0x10, 0x08, 0xB8, 0xBC, 0x99,
    0xA4, 0x1A, 0xE9, 0xE9, 0x56, 0x28, 0xBC, 0x64,
    0xF2, 0xF1, 0xB2, 0x0C, 0x2D, 0x7E, 0x9F, 0x51,
    0x77, 0xA3, 0xC2, 0x94, 0xD4, 0x46, 0x22, 0x99
};

/* RFC 6979 A.2.5: message "sample" — SHA-256("sample") */
static bool ecdsa_rfc6979_sample_sign(void)
{
    const uint8_t h[32] = {
        0xAF, 0x2B, 0xDB, 0xE1, 0xAA, 0x9B, 0x6E, 0xC1,
        0xE2, 0xAD, 0xE1, 0xD6, 0x94, 0xF4, 0x1F, 0xC7,
        0x1A, 0x83, 0x1D, 0x02, 0x68, 0xE9, 0x89, 0x15,
        0x62, 0x11, 0x3D, 0x8A, 0x62, 0xAD, 0xD1, 0xBF
    };
    const uint8_t exp_r[32] = {
        0xEF, 0xD4, 0x8B, 0x2A, 0xAC, 0xB6, 0xA8, 0xFD,
        0x11, 0x40, 0xDD, 0x9C, 0xD4, 0x5E, 0x81, 0xD6,
        0x9D, 0x2C, 0x87, 0x7B, 0x56, 0xAA, 0xF9, 0x91,
        0xC3, 0x4D, 0x0E, 0xA8, 0x4E, 0xAF, 0x37, 0x16
    };
    const uint8_t exp_s[32] = {
        0xF7, 0xCB, 0x1C, 0x94, 0x2D, 0x65, 0x7E, 0xF0,
        0x4F, 0xCE, 0x8A, 0x88, 0x5A, 0x74, 0x07, 0xCE,
        0x75, 0x1E, 0x6C, 0x02, 0x8F, 0x83, 0x52, 0x5F,
        0x5B, 0xB6, 0xB7, 0xDA, 0x62, 0xFD, 0xED, 0x26
    };

    uint8_t sig[64];
    if (!tls_p256_sign(sig, h, rfc6979_priv))
        return false;
    return memcmp(sig,      exp_r, 32) == 0 &&
           memcmp(sig + 32, exp_s, 32) == 0;
}

static bool ecdsa_rfc6979_sample_verify(void)
{
    const uint8_t h[32] = {
        0xAF, 0x2B, 0xDB, 0xE1, 0xAA, 0x9B, 0x6E, 0xC1,
        0xE2, 0xAD, 0xE1, 0xD6, 0x94, 0xF4, 0x1F, 0xC7,
        0x1A, 0x83, 0x1D, 0x02, 0x68, 0xE9, 0x89, 0x15,
        0x62, 0x11, 0x3D, 0x8A, 0x62, 0xAD, 0xD1, 0xBF
    };
    const uint8_t sig[64] = {
        0xEF, 0xD4, 0x8B, 0x2A, 0xAC, 0xB6, 0xA8, 0xFD,
        0x11, 0x40, 0xDD, 0x9C, 0xD4, 0x5E, 0x81, 0xD6,
        0x9D, 0x2C, 0x87, 0x7B, 0x56, 0xAA, 0xF9, 0x91,
        0xC3, 0x4D, 0x0E, 0xA8, 0x4E, 0xAF, 0x37, 0x16,
        0xF7, 0xCB, 0x1C, 0x94, 0x2D, 0x65, 0x7E, 0xF0,
        0x4F, 0xCE, 0x8A, 0x88, 0x5A, 0x74, 0x07, 0xCE,
        0x75, 0x1E, 0x6C, 0x02, 0x8F, 0x83, 0x52, 0x5F,
        0x5B, 0xB6, 0xB7, 0xDA, 0x62, 0xFD, 0xED, 0x26
    };
    return tls_p256_verify(sig, h, rfc6979_pub);
}

/* RFC 6979 A.2.5: message "test" — SHA-256("test") */
static bool ecdsa_rfc6979_test_sign(void)
{
    const uint8_t h[32] = {
        0x9F, 0x86, 0xD0, 0x81, 0x88, 0x4C, 0x7D, 0x65,
        0x9A, 0x2F, 0xEA, 0xA0, 0xC5, 0x5A, 0xD0, 0x15,
        0xA3, 0xBF, 0x4F, 0x1B, 0x2B, 0x0B, 0x82, 0x2C,
        0xD1, 0x5D, 0x6C, 0x15, 0xB0, 0xF0, 0x0A, 0x08
    };
    const uint8_t exp_r[32] = {
        0xF1, 0xAB, 0xB0, 0x23, 0x51, 0x83, 0x51, 0xCD,
        0x71, 0xD8, 0x81, 0x56, 0x7B, 0x1E, 0xA6, 0x63,
        0xED, 0x3E, 0xFC, 0xF6, 0xC5, 0x13, 0x2B, 0x35,
        0x4F, 0x28, 0xD3, 0xB0, 0xB7, 0xD3, 0x83, 0x67
    };
    const uint8_t exp_s[32] = {
        0x01, 0x9F, 0x4F, 0x69, 0x04, 0xBE, 0x8B, 0x97,
        0xB7, 0x91, 0x69, 0xB4, 0x80, 0x47, 0x53, 0x1C,
        0xE0, 0x6D, 0xAD, 0x7B, 0x6E, 0xF2, 0xA4, 0xCD,
        0x31, 0x20, 0xB9, 0x28, 0x74, 0xEB, 0x90, 0x5C
    };

    uint8_t sig[64];
    if (!tls_p256_sign(sig, h, rfc6979_priv))
        return false;
    return memcmp(sig,      exp_r, 32) == 0 &&
           memcmp(sig + 32, exp_s, 32) == 0;
}

static bool ecdsa_rfc6979_test_verify(void)
{
    const uint8_t h[32] = {
        0x9F, 0x86, 0xD0, 0x81, 0x88, 0x4C, 0x7D, 0x65,
        0x9A, 0x2F, 0xEA, 0xA0, 0xC5, 0x5A, 0xD0, 0x15,
        0xA3, 0xBF, 0x4F, 0x1B, 0x2B, 0x0B, 0x82, 0x2C,
        0xD1, 0x5D, 0x6C, 0x15, 0xB0, 0xF0, 0x0A, 0x08
    };
    const uint8_t sig[64] = {
        0xF1, 0xAB, 0xB0, 0x23, 0x51, 0x83, 0x51, 0xCD,
        0x71, 0xD8, 0x81, 0x56, 0x7B, 0x1E, 0xA6, 0x63,
        0xED, 0x3E, 0xFC, 0xF6, 0xC5, 0x13, 0x2B, 0x35,
        0x4F, 0x28, 0xD3, 0xB0, 0xB7, 0xD3, 0x83, 0x67,
        0x01, 0x9F, 0x4F, 0x69, 0x04, 0xBE, 0x8B, 0x97,
        0xB7, 0x91, 0x69, 0xB4, 0x80, 0x47, 0x53, 0x1C,
        0xE0, 0x6D, 0xAD, 0x7B, 0x6E, 0xF2, 0xA4, 0xCD,
        0x31, 0x20, 0xB9, 0x28, 0x74, 0xEB, 0x90, 0x5C
    };
    return tls_p256_verify(sig, h, rfc6979_pub);
}

/* =========================================================================
 * Additional ECDSA verify tests (NIST CAVP SigVer P-256/SHA-256)
 * ========================================================================= */

/* CAVP vector 1 — valid */
static bool ecdsa_cavp_verify_1(void)
{
    const uint8_t pub[65] = {
        0x04,
        0xE4, 0x24, 0xDC, 0x61, 0xD4, 0xBB, 0x3C, 0xB7,
        0xEF, 0x43, 0x44, 0xA7, 0xF8, 0x95, 0x7A, 0x0C,
        0x46, 0x28, 0xB0, 0xBE, 0x6A, 0xBF, 0x04, 0xB2,
        0xFB, 0xAE, 0xD3, 0x27, 0x4E, 0xFC, 0xBB, 0x31,
        0xEB, 0x7F, 0x56, 0x6E, 0x2B, 0x1D, 0xD8, 0x81,
        0xBE, 0x24, 0xDF, 0x32, 0x9D, 0x0B, 0xFB, 0xD0,
        0x6A, 0x2D, 0xD1, 0x07, 0xFB, 0xA7, 0xFB, 0xEB,
        0xBE, 0x70, 0x87, 0x7E, 0x54, 0xB8, 0xDC, 0x5B
    };
    const uint8_t h[32] = {
        0xA4, 0x1A, 0x41, 0xA1, 0x2A, 0x79, 0x95, 0x48,
        0x21, 0x16, 0x30, 0xC4, 0x0A, 0xB4, 0xF2, 0x42,
        0x59, 0xD0, 0xBB, 0x4B, 0x82, 0x44, 0x71, 0x3B,
        0x8D, 0xCE, 0x5B, 0xF6, 0x21, 0xE6, 0x40, 0x68
    };
    const uint8_t sig[64] = {
        0xCB, 0x28, 0xE0, 0x99, 0x9B, 0x9C, 0x77, 0x15,
        0xFD, 0x0A, 0x80, 0xD8, 0xE4, 0x7A, 0x77, 0x07,
        0x97, 0x16, 0xCB, 0xBF, 0x91, 0x7D, 0xD7, 0x2E,
        0x97, 0x56, 0x6E, 0xA1, 0xC0, 0x66, 0x95, 0x7C,
        0x86, 0xFA, 0x3B, 0xB4, 0xE2, 0x6C, 0xAD, 0x5B,
        0xF9, 0x0B, 0x7F, 0x81, 0x89, 0x92, 0x56, 0xCE,
        0x75, 0x94, 0xBB, 0x1E, 0xA0, 0xC8, 0x92, 0x12,
        0x74, 0x8B, 0xFF, 0x3B, 0x3D, 0x5B, 0x03, 0x15
    };
    return tls_p256_verify(sig, h, pub);
}

/* CAVP vector 2 — valid, different key */
static bool ecdsa_cavp_verify_2(void)
{
    const uint8_t pub[65] = {
        0x04,
        0x2B, 0xB0, 0x3B, 0x46, 0xA6, 0x34, 0x4C, 0xDB,
        0x05, 0x31, 0x3B, 0x8D, 0x83, 0xCE, 0x6B, 0x8E,
        0x45, 0xD1, 0xBB, 0x2B, 0xAD, 0x64, 0x40, 0x37,
        0x8A, 0x1A, 0xC8, 0xD7, 0xFC, 0x7B, 0x4D, 0x88,
        0x0E, 0x12, 0x6A, 0xCA, 0xC5, 0x16, 0xD9, 0x1E,
        0x18, 0x3F, 0x15, 0x65, 0x14, 0x72, 0xA8, 0x23,
        0xE0, 0x8B, 0xF0, 0xAF, 0x93, 0x96, 0x26, 0xF4,
        0x49, 0xFA, 0x95, 0x38, 0x0E, 0xB4, 0xD9, 0x51
    };
    const uint8_t h[32] = {
        0x59, 0x05, 0x23, 0x88, 0x77, 0xC7, 0x74, 0x21,
        0xF7, 0x3E, 0x43, 0xEE, 0x3D, 0xA6, 0xF2, 0xD9,
        0xE2, 0xCC, 0xAD, 0x5F, 0xC9, 0x42, 0xDC, 0xEC,
        0x0C, 0xBD, 0x25, 0x48, 0x29, 0x35, 0xFA, 0xAF
    };
    const uint8_t sig[64] = {
        0x67, 0x22, 0x76, 0x38, 0x09, 0x58, 0x64, 0x41,
        0x1A, 0x2D, 0xFF, 0xAF, 0x5F, 0xE0, 0xA7, 0x73,
        0x8B, 0x9C, 0x5C, 0x67, 0x3B, 0x16, 0x5A, 0x11,
        0x64, 0x9D, 0xF6, 0x49, 0xC8, 0xAB, 0xC5, 0x83,
        0x9D, 0x8C, 0x86, 0xB0, 0x50, 0xA0, 0x65, 0x2B,
        0x84, 0x33, 0x2A, 0x14, 0x55, 0x13, 0xCF, 0x76,
        0xC5, 0x19, 0x57, 0xDA, 0x6D, 0x89, 0x55, 0xEC,
        0xDB, 0x69, 0x26, 0x73, 0x31, 0xA2, 0x3C, 0x6B
    };
    return tls_p256_verify(sig, h, pub);
}

/* Rejection: s zeroed — must return false */
static bool ecdsa_cavp_reject_bad_sig(void)
{
    const uint8_t pub[65] = {
        0x04,
        0xE4, 0x24, 0xDC, 0x61, 0xD4, 0xBB, 0x3C, 0xB7,
        0xEF, 0x43, 0x44, 0xA7, 0xF8, 0x95, 0x7A, 0x0C,
        0x46, 0x28, 0xB0, 0xBE, 0x6A, 0xBF, 0x04, 0xB2,
        0xFB, 0xAE, 0xD3, 0x27, 0x4E, 0xFC, 0xBB, 0x31,
        0xEB, 0x7F, 0x56, 0x6E, 0x2B, 0x1D, 0xD8, 0x81,
        0xBE, 0x24, 0xDF, 0x32, 0x9D, 0x0B, 0xFB, 0xD0,
        0x6A, 0x2D, 0xD1, 0x07, 0xFB, 0xA7, 0xFB, 0xEB,
        0xBE, 0x70, 0x87, 0x7E, 0x54, 0xB8, 0xDC, 0x5B
    };
    const uint8_t h[32] = {
        0xA4, 0x1A, 0x41, 0xA1, 0x2A, 0x79, 0x95, 0x48,
        0x21, 0x16, 0x30, 0xC4, 0x0A, 0xB4, 0xF2, 0x42,
        0x59, 0xD0, 0xBB, 0x4B, 0x82, 0x44, 0x71, 0x3B,
        0x8D, 0xCE, 0x5B, 0xF6, 0x21, 0xE6, 0x40, 0x68
    };
    /* Valid r, s all-zeros — must reject */
    const uint8_t sig[64] = {
        0xCB, 0x28, 0xE0, 0x99, 0x9B, 0x9C, 0x77, 0x15,
        0xFD, 0x0A, 0x80, 0xD8, 0xE4, 0x7A, 0x77, 0x07,
        0x97, 0x16, 0xCB, 0xBF, 0x91, 0x7D, 0xD7, 0x2E,
        0x97, 0x56, 0x6E, 0xA1, 0xC0, 0x66, 0x95, 0x7C,
        0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
        0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
        0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
        0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
    };
    return !tls_p256_verify(sig, h, pub);
}

/* Rejection: correct sig, wrong public key */
static bool ecdsa_cavp_reject_wrong_key(void)
{
    const uint8_t h[32] = {
        0xA4, 0x1A, 0x41, 0xA1, 0x2A, 0x79, 0x95, 0x48,
        0x21, 0x16, 0x30, 0xC4, 0x0A, 0xB4, 0xF2, 0x42,
        0x59, 0xD0, 0xBB, 0x4B, 0x82, 0x44, 0x71, 0x3B,
        0x8D, 0xCE, 0x5B, 0xF6, 0x21, 0xE6, 0x40, 0x68
    };
    const uint8_t sig[64] = {
        0xCB, 0x28, 0xE0, 0x99, 0x9B, 0x9C, 0x77, 0x15,
        0xFD, 0x0A, 0x80, 0xD8, 0xE4, 0x7A, 0x77, 0x07,
        0x97, 0x16, 0xCB, 0xBF, 0x91, 0x7D, 0xD7, 0x2E,
        0x97, 0x56, 0x6E, 0xA1, 0xC0, 0x66, 0x95, 0x7C,
        0x86, 0xFA, 0x3B, 0xB4, 0xE2, 0x6C, 0xAD, 0x5B,
        0xF9, 0x0B, 0x7F, 0x81, 0x89, 0x92, 0x56, 0xCE,
        0x75, 0x94, 0xBB, 0x1E, 0xA0, 0xC8, 0x92, 0x12,
        0x74, 0x8B, 0xFF, 0x3B, 0x3D, 0x5B, 0x03, 0x15
    };
    /* rfc6979_pub is the wrong key for this (CAVP 1) signature */
    return !tls_p256_verify(sig, h, rfc6979_pub);
}

/* Rejection: correct sig and key, hash differs by 1 bit */
static bool ecdsa_cavp_reject_wrong_hash(void)
{
    const uint8_t pub[65] = {
        0x04,
        0xE4, 0x24, 0xDC, 0x61, 0xD4, 0xBB, 0x3C, 0xB7,
        0xEF, 0x43, 0x44, 0xA7, 0xF8, 0x95, 0x7A, 0x0C,
        0x46, 0x28, 0xB0, 0xBE, 0x6A, 0xBF, 0x04, 0xB2,
        0xFB, 0xAE, 0xD3, 0x27, 0x4E, 0xFC, 0xBB, 0x31,
        0xEB, 0x7F, 0x56, 0x6E, 0x2B, 0x1D, 0xD8, 0x81,
        0xBE, 0x24, 0xDF, 0x32, 0x9D, 0x0B, 0xFB, 0xD0,
        0x6A, 0x2D, 0xD1, 0x07, 0xFB, 0xA7, 0xFB, 0xEB,
        0xBE, 0x70, 0x87, 0x7E, 0x54, 0xB8, 0xDC, 0x5B
    };
    const uint8_t sig[64] = {
        0xCB, 0x28, 0xE0, 0x99, 0x9B, 0x9C, 0x77, 0x15,
        0xFD, 0x0A, 0x80, 0xD8, 0xE4, 0x7A, 0x77, 0x07,
        0x97, 0x16, 0xCB, 0xBF, 0x91, 0x7D, 0xD7, 0x2E,
        0x97, 0x56, 0x6E, 0xA1, 0xC0, 0x66, 0x95, 0x7C,
        0x86, 0xFA, 0x3B, 0xB4, 0xE2, 0x6C, 0xAD, 0x5B,
        0xF9, 0x0B, 0x7F, 0x81, 0x89, 0x92, 0x56, 0xCE,
        0x75, 0x94, 0xBB, 0x1E, 0xA0, 0xC8, 0x92, 0x12,
        0x74, 0x8B, 0xFF, 0x3B, 0x3D, 0x5B, 0x03, 0x15
    };
    uint8_t bad_h[32] = {
        0xA4, 0x1A, 0x41, 0xA1, 0x2A, 0x79, 0x95, 0x48,
        0x21, 0x16, 0x30, 0xC4, 0x0A, 0xB4, 0xF2, 0x42,
        0x59, 0xD0, 0xBB, 0x4B, 0x82, 0x44, 0x71, 0x3B,
        0x8D, 0xCE, 0x5B, 0xF6, 0x21, 0xE6, 0x40, 0x68
    };
    bad_h[0] ^= 0x01;
    return !tls_p256_verify(sig, bad_h, pub);
}

/* =========================================================================
 * Sign + verify round-trip tests (work with any k strategy)
 * ========================================================================= */

static bool ecdsa_roundtrip_seqhash(void)
{
    const uint8_t h[32] = {
        0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08,
        0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F, 0x10,
        0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17, 0x18,
        0x19, 0x1A, 0x1B, 0x1C, 0x1D, 0x1E, 0x1F, 0x20
    };
    uint8_t pub[65], sig[64];
    if (!tls_p256_publickey(pub, rfc6979_priv)) return false;
    if (!tls_p256_sign(sig, h, rfc6979_priv))   return false;
    return tls_p256_verify(sig, h, pub);
}

/* Edge: all-0xFF hash */
static bool ecdsa_roundtrip_allff(void)
{
    const uint8_t h[32] = {
        0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
        0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
        0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
        0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF
    };
    uint8_t pub[65], sig[64];
    if (!tls_p256_publickey(pub, rfc6979_priv)) return false;
    if (!tls_p256_sign(sig, h, rfc6979_priv))   return false;
    return tls_p256_verify(sig, h, pub);
}

/* Edge: all-0x00 hash */
static bool ecdsa_roundtrip_allzero(void)
{
    const uint8_t h[32] = {0};
    uint8_t pub[65], sig[64];
    if (!tls_p256_publickey(pub, rfc6979_priv)) return false;
    if (!tls_p256_sign(sig, h, rfc6979_priv))   return false;
    return tls_p256_verify(sig, h, pub);
}

/* =========================================================================
 * Timing
 * ========================================================================= */

#define TIMING_SAMPLES 16

typedef struct {
    clock_t avg;
    clock_t max_delta_pct; /* max |sample - avg| as integer percent of avg */
} op_timing_t;

typedef struct {
    op_timing_t pubkey;
    op_timing_t secret;
    op_timing_t sign;
    op_timing_t verify;
} timing_t;

static op_timing_t measure_op(clock_t samples[TIMING_SAMPLES])
{
    op_timing_t r;
    clock_t sum = 0;
    for (int i = 0; i < TIMING_SAMPLES; i++)
        sum += samples[i];
    r.avg = sum / TIMING_SAMPLES;

    clock_t max_delta = 0;
    for (int i = 0; i < TIMING_SAMPLES; i++) {
        clock_t delta = samples[i] > r.avg ? samples[i] - r.avg : r.avg - samples[i];
        if (delta > max_delta) max_delta = delta;
    }
    /* percent: (max_delta * 100) / avg, guarded against div-by-zero */
    r.max_delta_pct = r.avg ? (max_delta * 100) / r.avg : 0;
    return r;
}

static void fill_random(uint8_t *buf, size_t len)
{
    for (size_t i = 0; i < len; i++)
        buf[i] = (uint8_t)(rand() & 0xFF);
}

static void measure_timing(timing_t *t)
{
    clock_t pubkey_samples[TIMING_SAMPLES];
    clock_t secret_samples[TIMING_SAMPLES];
    clock_t sign_samples[TIMING_SAMPLES];
    clock_t verify_samples[TIMING_SAMPLES];

    uint8_t priv1[32], priv2[32];
    uint8_t pub1[65], pub2[65];
    uint8_t secret[32], h[32], sig[64];
    clock_t s, e;
    int si = 0; /* sample index, increments by 2 per ECDHE round */

    /* ECDHE timing: 8 rounds of 2 keypairs => 16 samples each for pubkey and secret */
    for (int round = 0; round < TIMING_SAMPLES / 2; round++) {
        fill_random(priv1, sizeof(priv1));
        fill_random(priv2, sizeof(priv2));

        s = clock(); tls_p256_publickey(pub1, priv1); e = clock();
        pubkey_samples[si] = e - s;

        s = clock(); tls_p256_publickey(pub2, priv2); e = clock();
        pubkey_samples[si + 1] = e - s;

        s = clock(); tls_p256_secret(secret, priv1, pub2); e = clock();
        secret_samples[si] = e - s;

        s = clock(); tls_p256_secret(secret, priv2, pub1); e = clock();
        secret_samples[si + 1] = e - s;

        si += 2;
    }
    t->pubkey = measure_op(pubkey_samples);
    t->secret = measure_op(secret_samples);

    /* ECDSA timing: collect exactly TIMING_SAMPLES valid sign+verify pairs.
     * Skip any iteration where sign fails (shouldn't happen with rfc6979_priv,
     * but guarded so a buggy impl doesn't corrupt the sample array). */
    int sign_n = 0, verify_n = 0;
    for (int attempts = 0; sign_n < TIMING_SAMPLES && attempts < TIMING_SAMPLES * 4; attempts++) {
        fill_random(h, sizeof(h));

        s = clock(); bool ok = tls_p256_sign(sig, h, rfc6979_priv); e = clock();
        if (!ok) continue;
        sign_samples[sign_n++] = e - s;

        s = clock(); tls_p256_verify(sig, h, rfc6979_pub); e = clock();
        verify_samples[verify_n++] = e - s;
    }
    t->sign   = measure_op(sign_samples);
    t->verify = measure_op(verify_samples);
}

/* =========================================================================
 * Main
 * ========================================================================= */

int main(void)
{
    bool all = true;
    bool r;

    os_ClrHome();
    printf("P-256 Contest Test Suite\n");
    printf("========================\n\n");

    printf("[ECDHE - RFC 5903 s8.1]\n");
    r = ecdhe_rfc5903_init_pubkey();    all &= r; print_result("init pubkey", r);
    r = ecdhe_rfc5903_resp_pubkey();    all &= r; print_result("resp pubkey", r);
    r = ecdhe_rfc5903_secret_init();    all &= r; print_result("secret i*Qr", r);
    r = ecdhe_rfc5903_secret_resp();    all &= r; print_result("secret r*Qi", r);

    os_GetKey();
    os_ClrHome();
    printf("[ECDSA Sign - RFC 6979 A.2.5]\n");
    r = ecdsa_rfc6979_sample_sign();    all &= r; print_result("sign 'sample'", r);
    r = ecdsa_rfc6979_test_sign();      all &= r; print_result("sign 'test'", r);

    printf("\n[ECDSA Verify - RFC 6979]\n");
    r = ecdsa_rfc6979_sample_verify();  all &= r; print_result("verify 'sample'", r);
    r = ecdsa_rfc6979_test_verify();    all &= r; print_result("verify 'test'", r);

    os_GetKey();
    os_ClrHome();
    printf("[ECDSA Verify - NIST CAVP]\n");
    r = ecdsa_cavp_verify_1();          all &= r; print_result("cavp valid 1", r);
    r = ecdsa_cavp_verify_2();          all &= r; print_result("cavp valid 2", r);
    r = ecdsa_cavp_reject_bad_sig();    all &= r; print_result("reject bad s", r);
    r = ecdsa_cavp_reject_wrong_key();  all &= r; print_result("reject bad key", r);
    r = ecdsa_cavp_reject_wrong_hash(); all &= r; print_result("reject bad hash", r);

    printf("\n[Round-trip]\n");
    r = ecdsa_roundtrip_seqhash();      all &= r; print_result("roundtrip seq", r);
    r = ecdsa_roundtrip_allff();        all &= r; print_result("roundtrip 0xFF", r);
    r = ecdsa_roundtrip_allzero();      all &= r; print_result("roundtrip 0x00", r);

    os_GetKey();
    os_ClrHome();
    printf("Overall: %s\n\n", all ? "ALL PASS" : "FAILURES PRESENT");

    if (all) {
        srand((unsigned int)clock());
        timing_t t;
        measure_timing(&t);
        printf("[Timing (n=%d)]\n", TIMING_SAMPLES);
        printf("%-10s %10s  %s\n", "Op", "Avg cyc", "Max delta%");
        printf("PublicKey  %10lu  %lu%%\n", (unsigned long)t.pubkey.avg, (unsigned long)t.pubkey.max_delta_pct);
        printf("Secret     %10lu  %lu%%\n", (unsigned long)t.secret.avg, (unsigned long)t.secret.max_delta_pct);
        printf("Sign       %10lu  %lu%%\n", (unsigned long)t.sign.avg,   (unsigned long)t.sign.max_delta_pct);
        printf("Verify     %10lu  %lu%%\n", (unsigned long)t.verify.avg, (unsigned long)t.verify.max_delta_pct);
    }

    os_GetKey();
    return 0;
}
