/*
 * P-256 assembly profiling target (standalone; see ../Makefile).
 *
 * Times tls_p256_publickey (a full 256-step ladder on G plus the affine
 * export) and the field/point primitives it is built from, using hardware
 * timer 1 clocked from the CPU clock, so every figure is in CPU cycles.
 * Milliseconds assume the stock 48 MHz clock.
 *
 * The keygen result is checked against the RFC 5903 section 8.1 initiator
 * key pair; ECDH and ECDSA verify are checked against RFC 5903 / RFC 6979
 * vectors, and the p-specific field routines are cross-checked against the
 * generic Montgomery core (edge values + pseudo-random operands).  Results
 * go to the home screen in two pages (and to the emulator console in
 * `make debug` builds).  Press any key to advance / exit.
 */
#include <stdbool.h>
#include <stdint.h>
#include <stdio.h>
#include <string.h>
#include <debug.h>
#include <sys/timers.h>
#include <ti/screen.h>
#include <ti/getcsc.h>

bool tls_p256_publickey(uint8_t public_key[65], const uint8_t private_key[32]);
bool tls_p256_secret(uint8_t ss[32], const uint8_t priv[32], const uint8_t peer[65]);
bool tls_p256_sign(uint8_t sig[64], const uint8_t hash[32], const uint8_t priv[32]);
bool tls_p256_verify(const uint8_t sig[64], const uint8_t hash[32], const uint8_t pub[65]);
/* Test shims, assembled with --defsym P256_TEST=1 (C ABI; 0 = mod p). */
void p256_test_mont_mul(uint8_t *out, const uint8_t *a, const uint8_t *b, uint8_t use_n);
void p256_test_fe_mul(uint8_t *out, const uint8_t *a, const uint8_t *b);
void p256_test_fe_sq(uint8_t *out, const uint8_t *a);
void p256_test_fe_add(uint8_t *out, const uint8_t *a, const uint8_t *b);
void p256_test_fe_sub(uint8_t *out, const uint8_t *a, const uint8_t *b);
void p256_test_mod_add(uint8_t *out, const uint8_t *a, const uint8_t *b, uint8_t use_n);
void p256_test_mod_sub(uint8_t *out, const uint8_t *a, const uint8_t *b, uint8_t use_n);
void p256_test_inv(uint8_t *out, const uint8_t *a, uint8_t use_n);
void p256_test_point_double(uint8_t out[96], const uint8_t in[96]);
void p256_test_point_add(uint8_t out[96], const uint8_t p[96], const uint8_t q[96]);
/* Variable-time verify engine (public data only).  madd/jadd return the
 * resulting "accumulator is O" flag. */
uint8_t p256_test_madd_vt(uint8_t out[96], const uint8_t acc[96], const uint8_t a[96], uint8_t acc_inf);
uint8_t p256_test_jadd_vt(uint8_t out[96], const uint8_t acc[96], const uint8_t t[96], uint8_t acc_inf);
void p256_test_ord_inv_vt(uint8_t out[32], const uint8_t a[32]);

#include "p256_vectors.h"

/* RFC 5903 section 8.1, initiator. */
static const uint8_t priv[32] = {
    0xc8,0x8f,0x01,0xf5,0x10,0xd9,0xac,0x3f,0x70,0xa2,0x92,0xda,0xa2,0x31,0x6d,0xe5,
    0x44,0xe9,0xaa,0xb8,0xaf,0xe8,0x40,0x49,0xc6,0x2a,0x9c,0x57,0x86,0x2d,0x14,0x33
};
static const uint8_t pub_expected[65] = {
    0x04,0xda,0xd0,0xb6,0x53,0x94,0x22,0x1c,0xf9,0xb0,0x51,0xe1,0xfe,0xca,0x57,0x87,
    0xd0,0x98,0xdf,0xe6,0x37,0xfc,0x90,0xb9,0xef,0x94,0x5d,0x0c,0x37,0x72,0x58,0x11,
    0x80,0x52,0x71,0xa0,0x46,0x1c,0xdb,0x82,0x52,0xd6,0x1f,0x1c,0x45,0x6f,0xa3,0xe5,
    0x9a,0xb1,0xf4,0x5b,0x33,0xac,0xcf,0x5f,0x58,0x38,0x9e,0x05,0x77,0xb8,0x99,0x0b,0xb3
};

/* RFC 5903 section 8.1 responder + shared secret (NOTE: the copy in
 * tests/upcoming/tls_p256 has a corrupted responder y that is off-curve); RFC 6979 A.2.5 P-256
 * key / SHA-256("sample") signature (same vectors as tests/upcoming/tls_p256). */
static const uint8_t responder_public[65] = {
    0x04,0xd1,0x2d,0xfb,0x52,0x89,0xc8,0xd4,0xf8,0x12,0x08,0xb7,0x02,0x70,0x39,0x8c,
    0x34,0x22,0x96,0x97,0x0a,0x0b,0xcc,0xb7,0x4c,0x73,0x6f,0xc7,0x55,0x44,0x94,0xbf,
    0x63,0x56,0xfb,0xf3,0xca,0x36,0x6c,0xc2,0x3e,0x81,0x57,0x85,0x4c,0x13,0xc5,0x8d,
    0x6a,0xac,0x23,0xf0,0x46,0xad,0xa3,0x0f,0x83,0x53,0xe7,0x4f,0x33,0x03,0x98,0x72,0xab
};
static const uint8_t shared_expected[32] = {
    0xd6,0x84,0x0f,0x6b,0x42,0xf6,0xed,0xaf,0xd1,0x31,0x16,0xe0,0xe1,0x25,0x65,0x20,
    0x2f,0xef,0x8e,0x9e,0xce,0x7d,0xce,0x03,0x81,0x24,0x64,0xd0,0x4b,0x94,0x42,0xde
};
static const uint8_t sign_private[32] = {
    0xc9,0xaf,0xa9,0xd8,0x45,0xba,0x75,0x16,0x6b,0x5c,0x21,0x57,0x67,0xb1,0xd6,0x93,
    0x4e,0x50,0xc3,0xdb,0x36,0xe8,0x9b,0x12,0x7b,0x8a,0x62,0x2b,0x12,0x0f,0x67,0x21
};
static const uint8_t sample_hash[32] = {
    0xaf,0x2b,0xdb,0xe1,0xaa,0x9b,0x6e,0xc1,0xe2,0xad,0xe1,0xd6,0x94,0xf4,0x1f,0xc7,
    0x1a,0x83,0x1d,0x02,0x68,0xe9,0x89,0x15,0x62,0x11,0x3d,0x8a,0x62,0xad,0xd1,0xbf
};
static const uint8_t sample_signature[64] = {
    0xef,0xd4,0x8b,0x2a,0xac,0xb6,0xa8,0xfd,0x11,0x40,0xdd,0x9c,0xd4,0x5e,0x81,0xd6,
    0x9d,0x2c,0x87,0x7b,0x56,0xaa,0xf9,0x91,0xc3,0x4d,0x0e,0xa8,0x4e,0xaf,0x37,0x16,
    0xf7,0xcb,0x1c,0x94,0x2d,0x65,0x7c,0x41,0xd4,0x36,0xc7,0xa1,0xb6,0xe2,0x9f,0x65,
    0xf3,0xe9,0x00,0xdb,0xb9,0xaf,0xf4,0x06,0x4d,0xc4,0xab,0x2f,0x84,0x3a,0xcd,0xa8
};
static uint8_t ss[32], sig[64], pk2[65], badpt[65];

/* Scalar-multiplication edge cases (generated with an affine Python
 * reference): k = 1, 2, n-1, n-2, n-3 times G (the co-Z ladder's
 * exceptional scalars are 0, 1, n-2, n-1), and ECDH with the valid peer
 * point (0, sqrt(b)) whose x = 0 takes the complete-ladder fallback. */
static const uint8_t ek[5][32] = {
{0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01},
{0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02},
{0xff,0xff,0xff,0xff,0x00,0x00,0x00,0x00,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xbc,0xe6,0xfa,0xad,0xa7,0x17,0x9e,0x84,0xf3,0xb9,0xca,0xc2,0xfc,0x63,0x25,0x50},
{0xff,0xff,0xff,0xff,0x00,0x00,0x00,0x00,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xbc,0xe6,0xfa,0xad,0xa7,0x17,0x9e,0x84,0xf3,0xb9,0xca,0xc2,0xfc,0x63,0x25,0x4f},
{0xff,0xff,0xff,0xff,0x00,0x00,0x00,0x00,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xbc,0xe6,0xfa,0xad,0xa7,0x17,0x9e,0x84,0xf3,0xb9,0xca,0xc2,0xfc,0x63,0x25,0x4e}
};
static const uint8_t epub[5][65] = {
{0x04,0x6b,0x17,0xd1,0xf2,0xe1,0x2c,0x42,0x47,0xf8,0xbc,0xe6,0xe5,0x63,0xa4,0x40,0xf2,0x77,0x03,0x7d,0x81,0x2d,0xeb,0x33,0xa0,0xf4,0xa1,0x39,0x45,0xd8,0x98,0xc2,0x96,0x4f,0xe3,0x42,0xe2,0xfe,0x1a,0x7f,0x9b,0x8e,0xe7,0xeb,0x4a,0x7c,0x0f,0x9e,0x16,0x2b,0xce,0x33,0x57,0x6b,0x31,0x5e,0xce,0xcb,0xb6,0x40,0x68,0x37,0xbf,0x51,0xf5},
{0x04,0x7c,0xf2,0x7b,0x18,0x8d,0x03,0x4f,0x7e,0x8a,0x52,0x38,0x03,0x04,0xb5,0x1a,0xc3,0xc0,0x89,0x69,0xe2,0x77,0xf2,0x1b,0x35,0xa6,0x0b,0x48,0xfc,0x47,0x66,0x99,0x78,0x07,0x77,0x55,0x10,0xdb,0x8e,0xd0,0x40,0x29,0x3d,0x9a,0xc6,0x9f,0x74,0x30,0xdb,0xba,0x7d,0xad,0xe6,0x3c,0xe9,0x82,0x29,0x9e,0x04,0xb7,0x9d,0x22,0x78,0x73,0xd1},
{0x04,0x6b,0x17,0xd1,0xf2,0xe1,0x2c,0x42,0x47,0xf8,0xbc,0xe6,0xe5,0x63,0xa4,0x40,0xf2,0x77,0x03,0x7d,0x81,0x2d,0xeb,0x33,0xa0,0xf4,0xa1,0x39,0x45,0xd8,0x98,0xc2,0x96,0xb0,0x1c,0xbd,0x1c,0x01,0xe5,0x80,0x65,0x71,0x18,0x14,0xb5,0x83,0xf0,0x61,0xe9,0xd4,0x31,0xcc,0xa9,0x94,0xce,0xa1,0x31,0x34,0x49,0xbf,0x97,0xc8,0x40,0xae,0x0a},
{0x04,0x7c,0xf2,0x7b,0x18,0x8d,0x03,0x4f,0x7e,0x8a,0x52,0x38,0x03,0x04,0xb5,0x1a,0xc3,0xc0,0x89,0x69,0xe2,0x77,0xf2,0x1b,0x35,0xa6,0x0b,0x48,0xfc,0x47,0x66,0x99,0x78,0xf8,0x88,0xaa,0xee,0x24,0x71,0x2f,0xc0,0xd6,0xc2,0x65,0x39,0x60,0x8b,0xcf,0x24,0x45,0x82,0x52,0x1a,0xc3,0x16,0x7d,0xd6,0x61,0xfb,0x48,0x62,0xdd,0x87,0x8c,0x2e},
{0x04,0x5e,0xcb,0xe4,0xd1,0xa6,0x33,0x0a,0x44,0xc8,0xf7,0xef,0x95,0x1d,0x4b,0xf1,0x65,0xe6,0xc6,0xb7,0x21,0xef,0xad,0xa9,0x85,0xfb,0x41,0x66,0x1b,0xc6,0xe7,0xfd,0x6c,0x78,0xcb,0x9b,0xf2,0xb6,0x67,0x00,0x82,0xc8,0xb4,0xf9,0x31,0xe5,0x9b,0x5d,0x13,0x27,0xd5,0x4f,0xca,0xc7,0xb0,0x47,0xc2,0x65,0x86,0x4e,0xd8,0x5d,0x82,0xaf,0xcd}
};
static const uint8_t xzero_pt[65] = {0x04,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x66,0x48,0x5c,0x78,0x0e,0x2f,0x83,0xd7,0x24,0x33,0xbd,0x5d,0x84,0xa0,0x6b,0xb6,0x54,0x1c,0x2a,0xf3,0x1d,0xae,0x87,0x17,0x28,0xbf,0x85,0x6a,0x17,0x4f,0x93,0xf4};
static const uint8_t xzero_ss[32] = {0x1b,0x2b,0x64,0x99,0x61,0x35,0x48,0xdc,0x17,0x11,0x77,0xed,0x60,0xc6,0x03,0x1c,0xaf,0x22,0x00,0x57,0xe9,0xc7,0x62,0xdc,0xb0,0x1d,0xa4,0xd0,0x3b,0x94,0xa6,0x15};

static const uint8_t zero_hash[32];

static bool check_edges(void)
{
    bool ok = true;
    for (uint8_t i = 0; i < sizeof ek / sizeof ek[0]; i++) {
        bool r = tls_p256_publickey(pk2, ek[i]) && memcmp(pk2, epub[i], 65) == 0;
        if (!r) dbg_printf("edge k[%u] FAIL\n", i);
        ok = ok && r;
    }
    {   /* x(P) = 0 peer point */
        bool r = tls_p256_secret(ss, priv, xzero_pt) && memcmp(ss, xzero_ss, 32) == 0;
        if (!r) dbg_printf("x=0 ECDH FAIL\n");
        ok = ok && r;
    }
    {   /* hash = 0 -> u1 = 0 in verify (scalar k = 0) */
        bool r = tls_p256_sign(sig, zero_hash, sign_private) &&
                 tls_p256_publickey(pk2, sign_private) &&
                 tls_p256_verify(sig, zero_hash, pk2);
        if (!r) dbg_printf("zero-hash sign/verify FAIL\n");
        ok = ok && r;
    }
    return ok;
}

/* Arbitrary operands below p (the public key's x/y/z happen to qualify). */
static uint8_t opa[96], opb[96], out[96], pub[65];

static uint8_t va[32], vb[32], r1[32], r2[32];
static uint32_t lcg = 0x12345678;
static uint8_t rnd8(void)
{
    lcg = lcg * 1103515245u + 12345u;
    return (uint8_t)(lcg >> 16);
}

/* Random operand < p.  mode picks a byte distribution that stresses
 * carries (0xFF-heavy) as well as uniform bytes; a top byte <= 0xFE
 * keeps the value below p = 0xFFFFFFFF00000001... */
static void rnd_fe(uint8_t *x, uint8_t mode)
{
    static const uint8_t pick[4] = { 0x00, 0xFF, 0xFE, 0x01 };
    for (uint8_t i = 0; i < 32; i++) {
        uint8_t r = rnd8();
        x[i] = (mode & 1) ? pick[r & 3] : r;
        if ((mode & 2) && (r & 0x80)) x[i] = 0xFF;
    }
    if (x[31] == 0xFF) x[31] = 0xFE;
}

static const uint8_t edge[16][32] = {
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    {0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    {0x02,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    {0xfe,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0xff,0xff,0xff,0xff},
    {0xfd,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0xff,0xff,0xff,0xff},
    {0xfc,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0xff,0xff,0xff,0xff},
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80},
    {0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xfe,0xff,0xff,0xff,0x00,0x00,0x00,0x00},
    {0xfe,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0x01,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x02,0x00,0x00,0x00,0xfe,0xff,0xff,0xff},
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00},
    {0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0xfe,0xff,0xff,0xff},
    {0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00},
    {0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0x7f,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x00,0x00,0x80,0xff,0xff,0xff,0x7f},
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x80,0x00,0x00,0x00,0x80,0xff,0xff,0xff,0x7f},
    {0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xfe,0xff,0xff,0xff},
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xff}
};

/* R mod p = Montgomery 1. */
static const uint8_t mont_one[32] = {
    0x01,0,0,0,0,0,0,0,0,0,0,0,0xff,0xff,0xff,0xff,
    0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xfe,0xff,0xff,0xff,0,0,0,0
};

/* Field inversion (addition chain) checked as inv(a) * a == 1. */
static unsigned check_inv(unsigned n)
{
    unsigned bad = 0;
    const unsigned ne = sizeof edge / sizeof edge[0];
    for (unsigned t = 0; t < n + ne; t++) {
        if (t < ne) memcpy(va, edge[t], 32); else rnd_fe(va, (uint8_t)t);
        if (!memcmp(va, edge[0], 32)) continue;          /* 0 has no inverse */
        p256_test_inv(r1, va, 0);
        p256_test_fe_mul(r1, r1, va);
        if (memcmp(r1, mont_one, 32)) { bad++; dbg_printf("inv mismatch t=%u\n", t); }
    }
    return bad;
}

/* Cross-check p-specific mul/sq against the generic Montgomery core. */
static unsigned check_fe(unsigned n)
{
    unsigned bad = 0;
    const unsigned ne = sizeof edge / sizeof edge[0];
    for (unsigned t = 0; t < n + ne * ne; t++) {
        if (t < ne * ne) {                    /* all edge-value pairs first */
            memcpy(va, edge[t / ne], 32);
            memcpy(vb, edge[t % ne], 32);
        } else {
            rnd_fe(va, (uint8_t)t);
            rnd_fe(vb, (uint8_t)(t >> 2));
        }
        p256_test_mont_mul(r2, va, vb, 0);
        p256_test_fe_mul(r1, va, vb);
        if (memcmp(r1, r2, 32)) { bad++; dbg_printf("mul mismatch t=%u\n", t); }
        memcpy(r1, va, 32);
        p256_test_fe_mul(r1, r1, vb);         /* out aliases a */
        if (memcmp(r1, r2, 32)) { bad++; dbg_printf("mul alias mismatch t=%u\n", t); }
        p256_test_mod_add(r2, va, vb, 0);
        p256_test_fe_add(r1, va, vb);
        if (memcmp(r1, r2, 32)) { bad++; dbg_printf("add mismatch t=%u\n", t); }
        memcpy(r1, vb, 32);
        p256_test_fe_add(r1, va, r1);         /* out aliases b */
        if (memcmp(r1, r2, 32)) { bad++; dbg_printf("add alias mismatch t=%u\n", t); }
        p256_test_mod_sub(r2, va, vb, 0);
        p256_test_fe_sub(r1, va, vb);
        if (memcmp(r1, r2, 32)) { bad++; dbg_printf("sub mismatch t=%u\n", t); }
        memcpy(r1, vb, 32);
        p256_test_fe_sub(r1, va, r1);         /* out aliases b */
        if (memcmp(r1, r2, 32)) { bad++; dbg_printf("sub alias mismatch t=%u\n", t); }
        p256_test_mod_sub(r2, vb, va, 0);
        p256_test_fe_sub(r1, vb, va);
        if (memcmp(r1, r2, 32)) { bad++; dbg_printf("sub2 mismatch t=%u\n", t); }
        p256_test_mont_mul(r2, va, va, 0);
        p256_test_fe_sq(r1, va);
        if (memcmp(r1, r2, 32)) { bad++; dbg_printf("sq mismatch t=%u\n", t); }
        memcpy(r1, va, 32);
        p256_test_fe_sq(r1, r1);              /* out aliases a */
        if (memcmp(r1, r2, 32)) { bad++; dbg_printf("sq alias mismatch t=%u\n", t); }
    }
    return bad;
}

/* ---- variable-time verify engine checks ---- */
static const uint8_t n_le[32] = {
    0x51,0x25,0x63,0xfc,0xc2,0xca,0xb9,0xf3,0x84,0x9e,0x17,0xa7,0xad,0xfa,0xe6,0xbc,
    0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0x00,0x00,0x00,0x00,0xff,0xff,0xff,0xff
};
static const uint8_t n_r2[32] = {   /* R^2 mod n */
    0xa2,0xee,0x79,0xbe,0x95,0x4c,0x24,0x83,0xa6,0x6f,0xbd,0x49,0x9c,0x79,0x99,0x46,
    0x59,0xec,0x6b,0x2b,0x39,0xb2,0x45,0x28,0x20,0x56,0xd9,0xf3,0x94,0x2d,0xe1,0x66
};
static const uint8_t one_le[32] = { 1 };
/* G in Montgomery-Jacobian form (Gx R, Gy R, R), as __p256_G. */
static const uint8_t g_jac[96] = {
    0x3c,0x14,0xa9,0x18,0xd4,0x30,0xe7,0x79,0x01,0xb6,0xed,0x5f,0xfc,0x95,0xba,0x75,
    0x10,0x25,0x62,0x77,0x2b,0x73,0xfb,0x79,0xc6,0x55,0x37,0xa5,0x76,0x5f,0x90,0x18,
    0x0a,0x56,0x95,0xce,0x57,0x53,0xf2,0xdd,0x5c,0xe4,0x19,0xba,0xe4,0xb8,0x4a,0x8b,
    0x25,0xf3,0x21,0xdd,0x88,0x86,0xe8,0xd2,0x85,0x5d,0x88,0x25,0x18,0xff,0x71,0x85,
    0x01,0,0,0,0,0,0,0,0,0,0,0,0xff,0xff,0xff,0xff,
    0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xff,0xfe,0xff,0xff,0xff,0,0,0,0
};
static uint8_t pt_a[96], pt_b[96], pt_c[96], pt_d[96], pt_gs[96], pt_gn[96];
static uint8_t fz[32], fa[32], fb[32], fc[32], fd[32];

static bool lt_n(const uint8_t *a)
{
    for (uint8_t i = 32; i--; )
        if (a[i] != n_le[i]) return a[i] < n_le[i];
    return false;
}

/* Projective equality of two finite Jacobian points (Z != 0). */
static bool pt_eq(const uint8_t *A, const uint8_t *B)
{
    if (!memcmp(A + 64, fz, 32) || !memcmp(B + 64, fz, 32)) return false;
    p256_test_fe_sq(fa, A + 64);
    p256_test_fe_sq(fb, B + 64);
    p256_test_fe_mul(fc, A, fb);
    p256_test_fe_mul(fd, B, fa);
    if (memcmp(fc, fd, 32)) return false;
    p256_test_fe_mul(fa, fa, A + 64);
    p256_test_fe_mul(fb, fb, B + 64);
    p256_test_fe_mul(fc, A + 32, fb);
    p256_test_fe_mul(fd, B + 32, fa);
    return !memcmp(fc, fd, 32);
}

#define VT_CHECK(cond, what) do { if (!(cond)) { bad++; dbg_printf("vt FAIL: %s\n", what); } } while (0)

static unsigned check_vt(unsigned nrand)
{
    unsigned bad = 0;
    const unsigned ne = sizeof edge / sizeof edge[0];
    uint8_t f;

    /* inv_vt(a) * a == 1 (mod n), checked as mont(mont(w, a), R^2) == 1. */
    for (unsigned t = 0; t < ne + nrand + 3; t++) {
        if (t < ne) memcpy(va, edge[t], 32);
        else if (t < ne + nrand) { rnd_fe(va, (uint8_t)t); if (va[31] == 0xff) va[31] = 0xfe; }
        else { memcpy(va, n_le, 32); va[0] -= (uint8_t)(t - ne - nrand + 1); } /* n-1, n-2, n-3 */
        if (!memcmp(va, edge[0], 32) || !lt_n(va)) continue;
        p256_test_ord_inv_vt(r1, va);
        p256_test_mont_mul(r2, r1, va, 1);
        p256_test_mont_mul(r2, r2, n_r2, 1);
        if (memcmp(r2, one_le, 32)) { bad++; dbg_printf("inv_vt mismatch t=%u\n", t); }
        /* constant-time chain: out = x^-1 R^2 for x = va, so mont(mont(out, x), 1) = 1 */
        p256_test_inv(r1, va, 1);
        p256_test_mont_mul(r2, r1, va, 1);
        p256_test_mont_mul(r2, r2, one_le, 1);
        if (memcmp(r2, one_le, 32)) { bad++; dbg_printf("ord_inv mismatch t=%u\n", t); }
    }

    /* Points: 2G, 3G (complete add), G scaled by lambda (same point, Z != 1), -G. */
    p256_test_point_double(pt_a, g_jac);                  /* 2G */
    p256_test_point_add(pt_b, pt_a, g_jac);               /* 3G */
    memcpy(pt_gs + 64, opa, 32);                          /* lambda < p, != 0 */
    p256_test_fe_sq(fa, pt_gs + 64);
    p256_test_fe_mul(pt_gs, g_jac, fa);
    p256_test_fe_mul(fa, fa, pt_gs + 64);
    p256_test_fe_mul(pt_gs + 32, g_jac + 32, fa);
    memcpy(pt_gn, g_jac, 96);
    p256_test_fe_sub(pt_gn + 32, fz, g_jac + 32);         /* -G */

    f = p256_test_madd_vt(pt_c, pt_a, g_jac, 0);          /* 2G + G */
    VT_CHECK(!f && pt_eq(pt_c, pt_b), "madd generic");
    f = p256_test_madd_vt(pt_c, pt_gs, g_jac, 0);         /* G + G -> doubling */
    p256_test_point_double(pt_d, g_jac);
    VT_CHECK(!f && pt_eq(pt_c, pt_d), "madd doubling");
    f = p256_test_madd_vt(pt_c, pt_gs, pt_gn, 0);         /* G + -G -> O */
    VT_CHECK(f == 1, "madd inverse");
    f = p256_test_madd_vt(pt_c, pt_b, g_jac, 1);          /* O + G -> (x, y, 1) */
    VT_CHECK(!f && !memcmp(pt_c, g_jac, 96), "madd from O");

    p256_test_point_add(pt_d, pt_a, pt_b);                /* 5G */
    f = p256_test_jadd_vt(pt_c, pt_a, pt_b, 0);
    VT_CHECK(!f && pt_eq(pt_c, pt_d), "jadd generic");
    f = p256_test_jadd_vt(pt_c, pt_gs, g_jac, 0);         /* doubling */
    p256_test_point_double(pt_d, g_jac);
    VT_CHECK(!f && pt_eq(pt_c, pt_d), "jadd doubling");
    f = p256_test_jadd_vt(pt_c, pt_gs, pt_gn, 0);         /* O */
    VT_CHECK(f == 1, "jadd inverse");
    f = p256_test_jadd_vt(pt_c, pt_a, pt_b, 1);           /* O + 3G */
    VT_CHECK(!f && !memcmp(pt_c, pt_b, 96), "jadd from O");

    /* Verify vectors (expectations from pyca/cryptography), plus tampering. */
    for (uint8_t i = 0; i < sizeof vvecs / sizeof vvecs[0]; i++) {
        const struct vvec *v = &vvecs[i];
        bool r = tls_p256_verify(v->sig, v->hash, v->pub);
        if (r != v->ok) { bad++; dbg_printf("verify vector %s: got %u\n", v->name, r); }
        if (v->ok && i < 7) {
            memcpy(sig, v->sig, 64); sig[5] ^= 0x10;          /* r */
            if (tls_p256_verify(sig, v->hash, v->pub)) { bad++; dbg_printf("tamper r %s\n", v->name); }
            memcpy(r1, v->hash, 32); r1[31] ^= 0x01;          /* hash */
            if (tls_p256_verify(v->sig, r1, v->pub)) { bad++; dbg_printf("tamper e %s\n", v->name); }
        }
    }
    return bad;
}

static void timer_start(void)
{
    timer_Disable(1);
    timer_Set(1, 0);
    timer_Enable(1, TIMER_CPU, TIMER_NOINT, TIMER_UP);
}

static uint32_t timer_cycles(void)
{
    return timer_GetSafe(1, TIMER_UP);
}

static void report(const char *name, uint32_t cycles)
{
    printf("%-8s%9lu cc\n", name, (unsigned long)cycles);
    dbg_printf("%s: %lu cycles\n", name, (unsigned long)cycles);
}

int main(void)
{
    uint32_t c, ms;
    bool ok;

    os_ClrHome();
    dbg_printf("P-256 profiling\n");     /* screen has 9 lines: no title */

    /* Operands: x/y of the expected public key, reversed to LE (< p). */
    for (uint8_t i = 0; i < 32; i++) {
        opa[i]      = pub_expected[32 - i];
        opa[32 + i] = pub_expected[64 - i];
        opa[64 + i] = pub_expected[32 - i] ^ pub_expected[64 - i];
    }
    opa[95] &= 0x7f;                      /* keep z < p */
    memcpy(opb, opa + 32, 64);
    memcpy(opb + 64, opa, 32);

    {
        unsigned bad = check_fe(400) + check_inv(24);
        printf("fe check %u bad\n", bad);
        dbg_printf("fe check (%u cmp + inv): %u bad\n", 9u * (400u + (unsigned)(sizeof edge / sizeof edge[0]) * (unsigned)(sizeof edge / sizeof edge[0])), bad);
    }
    timer_start(); p256_test_mont_mul(out, opa, opb, 0); report("mont_mul", timer_cycles());
    timer_start(); p256_test_fe_mul(out, opa, opb);      report("fe_mul", timer_cycles());
    timer_start(); p256_test_fe_sq(out, opa);            report("fe_sq", timer_cycles());
    timer_start(); p256_test_inv(out, opa, 0);
    c = timer_cycles(); dbg_printf("fe_inv: %lu cycles\n", (unsigned long)c);
    memcpy(va, opa, 32); va[31] &= 0x7f;                 /* < n */
    timer_start(); p256_test_inv(out, va, 1);
    c = timer_cycles(); dbg_printf("ord_inv: %lu cycles\n", (unsigned long)c);
    timer_start(); p256_test_ord_inv_vt(out, va);
    c = timer_cycles(); dbg_printf("ord_inv_vt: %lu cycles\n", (unsigned long)c);
    timer_start(); p256_test_madd_vt(out, opa, opb, 0);
    c = timer_cycles(); dbg_printf("madd_vt: %lu cycles\n", (unsigned long)c);
    timer_start(); p256_test_jadd_vt(out, opa, opb, 0);
    c = timer_cycles(); dbg_printf("jadd_vt: %lu cycles\n", (unsigned long)c);
    timer_start(); p256_test_mod_add(out, opa, opb, 0);  c = timer_cycles();
    dbg_printf("mod_add: %lu cycles\n", (unsigned long)c);  /* generic; console only */
    timer_start(); p256_test_mod_sub(out, opa, opb, 0);  c = timer_cycles();
    dbg_printf("mod_sub: %lu cycles\n", (unsigned long)c);  /* generic; console only */
    timer_start(); p256_test_fe_add(out, opa, opb);      report("fe_add", timer_cycles());
    timer_start(); p256_test_fe_sub(out, opa, opb);      report("fe_sub", timer_cycles());
    timer_start(); p256_test_point_double(out, opa);     report("pt_dbl", timer_cycles());
    timer_start(); p256_test_point_add(out, opa, opb);   report("pt_add", timer_cycles());

    puts("Any key: next");                /* page 1 = primitives */
    while (!os_GetCSC())
        ;
    os_ClrHome();

    timer_start();
    ok = tls_p256_publickey(pub, priv);
    c = timer_cycles();
    ok = ok && memcmp(pub, pub_expected, sizeof pub) == 0;
    ms = c / 48000;
    report("keygen", c);
    printf("P-256 keygen: %lums %s\n", (unsigned long)ms, ok ? "PASS" : "FAIL");
    dbg_printf("P-256 keygen: %lums %s\n", (unsigned long)ms, ok ? "PASS" : "FAIL");

    {
        bool e, v, vneg, rej, sg;
        timer_start();
        e = tls_p256_secret(ss, priv, responder_public) &&
            memcmp(ss, shared_expected, 32) == 0;
        report("ecdh", timer_cycles());
        timer_start();
        sg = tls_p256_sign(sig, sample_hash, sign_private) &&
             memcmp(sig, sample_signature, 64) == 0;
        report("sign", timer_cycles());
        v = tls_p256_publickey(pk2, sign_private);
        timer_start();
        v = v && tls_p256_verify(sample_signature, sample_hash, pk2);
        report("verify", timer_cycles());
        memcpy(sig, sample_signature, 64); sig[63] ^= 1;
        vneg = !tls_p256_verify(sig, sample_hash, pk2);
        memcpy(badpt, responder_public, 65); badpt[64] ^= 1;
        memset(ss, 0, 32);
        rej = !tls_p256_publickey(pk2, ss) && !tls_p256_secret(ss, priv, badpt);
        printf("dh %s sg %s vf %s ng %s rj %s\n", e ? "ok" : "BAD", sg ? "ok" : "BAD",
               v ? "ok" : "BAD", vneg ? "ok" : "BAD", rej ? "ok" : "BAD");
        dbg_printf("ECDH: %s  SIGN: %s  VERIFY: %s  VERIFY-NEG: %s  REJECT: %s\n",
                   e ? "PASS" : "FAIL", sg ? "PASS" : "FAIL", v ? "PASS" : "FAIL",
                   vneg ? "PASS" : "FAIL", rej ? "PASS" : "FAIL");
        ok = ok && e && sg && v && vneg && rej;
        {
            bool ed = check_edges();
            unsigned vb = check_vt(24);
            printf("edge %s vt %u bad\n", ed ? "ok" : "BAD", vb);
            dbg_printf("EDGE CASES: %s  VT CHECKS: %u bad\n", ed ? "PASS" : "FAIL", vb);
            ed = ed && !vb;
            ok = ok && ed;
        }
    }
    puts("Press any key");
    while (!os_GetCSC())
        ;
    return ok ? 0 : 1;
}
